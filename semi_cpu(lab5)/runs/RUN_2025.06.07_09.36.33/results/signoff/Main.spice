* NGSPICE file created from Main.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_1 abstract view
.subckt sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_1 abstract view
.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_2 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_1 abstract view
.subckt sky130_fd_sc_hd__clkinv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_2 abstract view
.subckt sky130_fd_sc_hd__dlxtn_2 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_1 abstract view
.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_2 abstract view
.subckt sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_4 abstract view
.subckt sky130_fd_sc_hd__and4bb_4 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_2 abstract view
.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_4 abstract view
.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 VGND VNB VPB VPWR HI LO
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_2 abstract view
.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

.subckt Main VGND VPWR an[0] an[1] an[2] an[3] an[4] an[5] an[6] an[7] clk cx[0] cx[1]
+ cx[2] cx[3] cx[4] cx[5] cx[6] cx[7] next rst
XTAP_TAPCELL_ROW_77_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3155_ _0361_ _0369_ _1545_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_27_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2037_ _1757_ _0524_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__and2_1
X_2106_ _0591_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__clkbuf_4
X_3086_ _1518_ _1519_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__nor2_1
X_2939_ _1391_ _1393_ _1398_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__or3b_1
XFILLER_0_43_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_66_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3773_ clknet_4_8_0_clk _0220_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_2724_ _1039_ _1044_ _0956_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__mux2_1
X_2655_ _1130_ _1131_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3207_ reg_file.memory\[5\]\[14\] alu.ALUResult\[14\] _1584_ VGND VGND VPWR VPWR
+ _1589_ sky130_fd_sc_hd__mux2_1
X_2586_ _1021_ _1065_ _0699_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3069_ clk_div.counter\[5\] _1505_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__and2_1
X_3138_ _1552_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2440_ _0749_ _0751_ _0789_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_79_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2371_ _0661_ _0855_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_62_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
X_3756_ clknet_4_4_0_clk _0203_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2707_ _1174_ _1180_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__xnor2_1
X_3687_ clknet_4_0_0_clk _0134_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2569_ _1027_ _1030_ _1049_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__a21oi_1
X_2638_ _1102_ _1103_ _1115_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_4_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1871_ _0361_ _0369_ _0364_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3610_ clk_div.slow_clk _0057_ VGND VGND VPWR VPWR seven_seg_conv.temp\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1940_ alu.ALUResult\[11\] seven_seg_conv.temp\[11\] _1752_ VGND VGND VPWR VPWR _0439_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_16_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2423_ _0902_ _0905_ _0906_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__mux2_1
X_3541_ _0247_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[15\] sky130_fd_sc_hd__dlxtn_1
X_3472_ _1727_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2354_ _0678_ _0838_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2285_ _0583_ _0769_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3739_ clknet_4_15_0_clk _0186_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2070_ _0010_ _0011_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2972_ _0796_ _1427_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__or2_1
XFILLER_0_56_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1854_ _0346_ _0347_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__nand2_1
X_1785_ _0283_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__inv_2
X_1923_ _0414_ _0416_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2406_ _0726_ _0889_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__or2_1
X_3386_ reg_file.memory\[15\]\[4\] alu.ALUResult\[4\] _1677_ VGND VGND VPWR VPWR _1682_
+ sky130_fd_sc_hd__mux2_1
X_3455_ _1718_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__clkbuf_1
X_3524_ net1 _0015_ net2 VGND VGND VPWR VPWR PC\[2\] sky130_fd_sc_hd__dfrtp_2
X_2337_ _0803_ _0821_ _0725_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__mux2_2
X_2199_ _0592_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2268_ reg_file.memory\[25\]\[3\] _0662_ _0752_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__o21a_1
XFILLER_0_62_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3240_ reg_file.memory\[5\]\[30\] alu.ALUResult\[30\] _1572_ VGND VGND VPWR VPWR
+ _1606_ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2122_ reg_file.memory\[5\]\[30\] reg_file.memory\[15\]\[30\] _0603_ VGND VGND VPWR
+ VPWR _0608_ sky130_fd_sc_hd__mux2_1
X_3171_ _1543_ seven_seg_conv.temp\[26\] _0311_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__a21o_1
X_2053_ seven_seg_conv.digit_counter\[3\] seven_seg_conv.current_digit\[3\] _0548_
+ _0549_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__a22o_1
X_2955_ _1170_ _1375_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_32_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1837_ _0327_ _0335_ _0332_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__o21ai_2
X_3507_ _1745_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__clkbuf_1
X_2886_ _1227_ _1348_ _0910_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__mux2_1
X_1906_ _0394_ _0402_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__xor2_1
X_1768_ _1754_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__inv_2
X_3369_ _1672_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__clkbuf_1
X_3438_ reg_file.memory\[15\]\[29\] alu.ALUResult\[29\] _1699_ VGND VGND VPWR VPWR
+ _1709_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_55_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput7 net7 VGND VGND VPWR VPWR an[4] sky130_fd_sc_hd__buf_1
XFILLER_0_53_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2740_ _0977_ _1063_ _1068_ _1118_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__o22a_1
X_2671_ _1145_ _1146_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_69_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3223_ _1597_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_77_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3154_ _1560_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__clkbuf_1
X_2036_ _1754_ _0533_ _0534_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__or3_1
X_2105_ _0585_ _0588_ _0590_ _0581_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__a31oi_4
X_3085_ clk_div.counter\[10\] _1516_ clk_div.counter\[11\] VGND VGND VPWR VPWR _1519_
+ sky130_fd_sc_hd__a21oi_1
X_2938_ _1118_ _0891_ _1256_ _1274_ _1397_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__o221a_1
XFILLER_0_43_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2869_ _1324_ _1332_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3772_ clknet_4_8_0_clk _0219_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_2723_ _1116_ _1038_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__or2_1
X_2585_ _0686_ _0916_ _0923_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_1_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2654_ _0711_ _1129_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__or2_1
X_3206_ _1588_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__clkbuf_1
X_3137_ seven_seg_conv.temp\[10\] _0447_ _1534_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3068_ _1508_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
X_2019_ _1758_ _0515_ _0517_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__or3_1
XFILLER_0_72_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2370_ reg_file.memory\[25\]\[16\] _0664_ _0854_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_62_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3686_ clknet_4_11_0_clk _0133_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_54_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2706_ _1178_ _1179_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__and2b_1
X_3755_ clknet_4_5_0_clk _0202_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_2499_ _0860_ _0981_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__or2_1
XFILLER_0_64_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2637_ _0872_ _1106_ _1110_ _1114_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2568_ _0739_ _1048_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1870_ _0363_ _0364_ _0367_ _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__a2bb2o_1
X_3540_ _0246_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[14\] sky130_fd_sc_hd__dlxtn_1
X_2353_ _0714_ _0837_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__nand2_1
X_2422_ _0888_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_51_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3471_ reg_file.memory\[25\]\[12\] alu.ALUResult\[12\] _1724_ VGND VGND VPWR VPWR
+ _1727_ sky130_fd_sc_hd__mux2_1
X_2284_ reg_file.memory\[5\]\[4\] reg_file.memory\[15\]\[4\] _0594_ VGND VGND VPWR
+ VPWR _0769_ sky130_fd_sc_hd__mux2_1
X_3738_ clknet_4_15_0_clk _0185_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_3669_ clknet_4_13_0_clk _0116_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1999_ _0487_ _0493_ _0497_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_13_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2971_ _0796_ _1427_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__and2_1
X_1922_ _0275_ _0410_ _0416_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_8_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1853_ _0343_ _0351_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__xor2_1
XFILLER_0_56_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1784_ alu.ALUResult\[17\] seven_seg_conv.temp\[17\] _1752_ VGND VGND VPWR VPWR _0283_
+ sky130_fd_sc_hd__mux2_1
X_3523_ net1 _0014_ net2 VGND VGND VPWR VPWR PC\[1\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2336_ _0811_ _0820_ _0698_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__mux2_1
X_2405_ _0884_ _0887_ _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__mux2_1
X_3385_ _1681_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__clkbuf_1
X_3454_ reg_file.memory\[25\]\[4\] alu.ALUResult\[4\] _1713_ VGND VGND VPWR VPWR _1718_
+ sky130_fd_sc_hd__mux2_1
X_2198_ _0676_ _0683_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2267_ reg_file.memory\[0\]\[3\] _0575_ _0667_ reg_file.memory\[10\]\[3\] _0670_
+ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__a221o_1
XFILLER_0_47_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3170_ _1569_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_67_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2121_ _0585_ _0606_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__nand2_1
X_2052_ _0535_ _0538_ seven_seg_conv.digit_counter\[3\] VGND VGND VPWR VPWR _0549_
+ sky130_fd_sc_hd__a21oi_1
X_2954_ _1405_ _1406_ _1412_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__o21bai_1
X_2885_ _1287_ _1347_ _0765_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__mux2_1
X_1905_ _0402_ _0403_ _0281_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_32_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1836_ _0330_ _0291_ _0324_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__and3_1
X_3506_ reg_file.memory\[25\]\[29\] alu.ALUResult\[29\] _1735_ VGND VGND VPWR VPWR
+ _1745_ sky130_fd_sc_hd__mux2_1
X_1767_ alu.ALUResult\[1\] seven_seg_conv.temp\[1\] _1753_ VGND VGND VPWR VPWR _1754_
+ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2319_ reg_file.memory\[0\]\[27\] _0783_ _0784_ reg_file.memory\[10\]\[27\] _0785_
+ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__a221o_1
X_3299_ _1635_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__clkbuf_1
X_3368_ alu.ALUResult\[28\] reg_file.memory\[10\]\[28\] _1663_ VGND VGND VPWR VPWR
+ _1672_ sky130_fd_sc_hd__mux2_1
X_3437_ _1708_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput8 net8 VGND VGND VPWR VPWR an[5] sky130_fd_sc_hd__buf_1
Xoutput10 net10 VGND VGND VPWR VPWR an[7] sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2670_ _1130_ _1139_ _1144_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3222_ reg_file.memory\[5\]\[21\] alu.ALUResult\[21\] _1595_ VGND VGND VPWR VPWR
+ _1597_ sky130_fd_sc_hd__mux2_1
X_3153_ seven_seg_conv.temp\[18\] _0377_ _0544_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__mux2_1
X_2104_ reg_file.memory\[5\]\[0\] _0589_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__nand2_1
X_2035_ _1756_ _0530_ _0532_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__and3_1
X_3084_ clk_div.counter\[10\] clk_div.counter\[11\] _1516_ VGND VGND VPWR VPWR _1518_
+ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2937_ _0877_ _1336_ _1396_ _0871_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__a211o_1
X_2868_ _1329_ _1331_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__nand2_1
X_1819_ _0312_ _0314_ _0316_ _0317_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__a22o_1
X_2799_ _0656_ _1266_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_15_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3771_ clknet_4_11_0_clk _0218_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_2722_ _1036_ _1194_ _1096_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2584_ _1061_ _1063_ _0956_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2653_ _0711_ _1129_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3205_ reg_file.memory\[5\]\[13\] alu.ALUResult\[13\] _1584_ VGND VGND VPWR VPWR
+ _1588_ sky130_fd_sc_hd__mux2_1
X_3067_ _1497_ _1506_ _1507_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__and3_1
X_3136_ _1551_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2018_ _0507_ _0511_ _0514_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__and3_1
XFILLER_0_70_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_79_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3685_ clknet_4_11_0_clk _0132_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_61_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2636_ _0579_ _1111_ _1113_ _0781_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__a211o_1
X_2705_ _0706_ _1177_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__nand2_1
X_3754_ clknet_4_0_0_clk _0201_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_2498_ _0921_ _0794_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2567_ _0780_ _1047_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_27_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3119_ seven_seg_conv.temp\[4\] _1539_ _1534_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_45_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_54_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_63_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2352_ reg_file.memory\[25\]\[20\] _0664_ _0836_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__o21a_1
X_2421_ _0903_ _0904_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__nand2_1
X_2283_ _0729_ _0747_ _0767_ _0579_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__a211oi_1
X_3470_ _1726_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_72_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3737_ clknet_4_14_0_clk _0184_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3668_ clknet_4_7_0_clk _0115_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_7_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3599_ clk_div.slow_clk _0046_ VGND VGND VPWR VPWR seven_seg_conv.temp\[5\] sky130_fd_sc_hd__dfxtp_1
X_1998_ _0482_ _0488_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__or2_1
X_2619_ _0579_ _1094_ _1097_ _0777_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__a211o_1
XFILLER_0_76_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_3_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2970_ _0611_ _1426_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__xnor2_1
X_1852_ _0348_ _0350_ _0344_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__a21oi_1
X_1921_ _0410_ _0417_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__xor2_1
X_1783_ alu.ALUResult\[16\] seven_seg_conv.temp\[16\] _1752_ VGND VGND VPWR VPWR _0282_
+ sky130_fd_sc_hd__mux2_1
X_3453_ _1717_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__clkbuf_1
X_3522_ net1 _0013_ net2 VGND VGND VPWR VPWR PC\[0\] sky130_fd_sc_hd__dfrtp_4
XFILLER_0_24_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2335_ _0815_ _0819_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__nand2_1
X_2404_ _0698_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__buf_4
X_3384_ reg_file.memory\[15\]\[3\] alu.ALUResult\[3\] _1677_ VGND VGND VPWR VPWR _1681_
+ sky130_fd_sc_hd__mux2_1
X_2266_ reg_file.memory\[25\]\[2\] _0662_ _0750_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__o21a_2
XFILLER_0_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2197_ _0679_ _0682_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2120_ reg_file.memory\[5\]\[26\] reg_file.memory\[15\]\[26\] _0603_ VGND VGND VPWR
+ VPWR _0606_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2051_ _0535_ _0540_ _0538_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__a21o_1
X_1835_ _0332_ _0331_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__and2_1
X_2884_ _1345_ _1346_ _0699_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__mux2_1
X_2953_ _1118_ _0983_ _1411_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__o21ai_1
X_1904_ _0282_ _0399_ _0401_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_32_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3505_ _1744_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__clkbuf_1
X_3436_ reg_file.memory\[15\]\[28\] alu.ALUResult\[28\] _1699_ VGND VGND VPWR VPWR
+ _1708_ sky130_fd_sc_hd__mux2_1
X_1766_ _1752_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__buf_4
X_3298_ reg_file.memory\[0\]\[27\] VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__clkbuf_1
X_3367_ _1671_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__clkbuf_1
X_2318_ _0794_ _0802_ _0719_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__mux2_1
X_2249_ reg_file.memory\[0\]\[7\] _0665_ _0668_ reg_file.memory\[10\]\[7\] _0671_
+ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__a221o_1
XFILLER_0_67_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput9 net9 VGND VGND VPWR VPWR an[6] sky130_fd_sc_hd__buf_1
Xoutput11 net11 VGND VGND VPWR VPWR cx[1] sky130_fd_sc_hd__buf_1
XFILLER_0_58_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3221_ _1596_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__clkbuf_1
X_3152_ _1543_ seven_seg_conv.temp\[17\] _1559_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__a21bo_1
X_2103_ _0574_ _0576_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__nand2_1
X_3083_ clk_div.counter\[10\] _1516_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__xor2_1
XFILLER_0_76_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2034_ _0530_ _0532_ _1756_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_11_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1818_ _0292_ _0301_ _0302_ _0310_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__or4b_1
X_2936_ _0728_ _1395_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_60_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2867_ _1330_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__inv_2
X_2798_ _0654_ _1250_ _1175_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_32_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3419_ _1676_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_7_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3770_ clknet_4_12_0_clk _0217_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_2721_ _0729_ _1192_ _1193_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__o21a_1
XFILLER_0_14_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2652_ _0643_ _1128_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__xnor2_1
X_2583_ _1062_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__inv_2
XFILLER_0_38_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3204_ _1587_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3066_ clk_div.counter\[3\] _1501_ clk_div.counter\[4\] VGND VGND VPWR VPWR _1507_
+ sky130_fd_sc_hd__a21o_1
X_2017_ _0506_ _0515_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__xor2_1
X_3135_ seven_seg_conv.temp\[9\] _1550_ _1534_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2919_ _0817_ _1379_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_71_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_79_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3684_ clknet_4_10_0_clk _0131_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_2635_ _0578_ _1112_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2704_ _0706_ _1177_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__nor2_1
X_3753_ clknet_4_0_0_clk _0200_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_2497_ _0921_ _0811_ _0979_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2566_ _0862_ _0866_ _0993_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__a21oi_1
X_3049_ clk_div.counter\[19\] clk_div.counter\[18\] clk_div.counter\[3\] clk_div.counter\[2\]
+ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__or4b_1
XTAP_TAPCELL_ROW_2_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3118_ _0492_ _0500_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2420_ _0749_ _0852_ _0686_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__a21o_1
X_2351_ reg_file.memory\[0\]\[20\] _0666_ _0669_ reg_file.memory\[10\]\[20\] _0672_
+ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__a221o_1
X_2282_ _0748_ _0756_ _0759_ _0764_ _0766_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__o221a_1
XFILLER_0_19_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3736_ clknet_4_13_0_clk _0183_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_1997_ seven_seg_conv.temp\[5\] _0279_ _0495_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__o21a_1
XFILLER_0_15_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3667_ clknet_4_7_0_clk _0114_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_7_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3598_ clk_div.slow_clk _0045_ VGND VGND VPWR VPWR seven_seg_conv.temp\[4\] sky130_fd_sc_hd__dfxtp_1
X_2549_ _0996_ _0999_ _1029_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__nand3_1
X_2618_ _0766_ _0973_ _1095_ _1096_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__o211a_1
XFILLER_0_33_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1851_ _0349_ _0341_ _0340_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1920_ _0273_ _0417_ _0418_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__or3_1
XFILLER_0_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3521_ _1489_ net3 _1753_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__o21a_1
X_2403_ _0885_ _0886_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__or2_1
X_1782_ seven_seg_conv.temp\[15\] _0279_ _0280_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__o21ai_2
X_3383_ _1680_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__clkbuf_1
X_3452_ reg_file.memory\[25\]\[3\] alu.ALUResult\[3\] _1713_ VGND VGND VPWR VPWR _1717_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2334_ _0678_ _0818_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__nand2_1
X_2196_ _0661_ _0681_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__nand2_1
X_2265_ reg_file.memory\[0\]\[2\] _0575_ _0667_ reg_file.memory\[10\]\[2\] _0670_
+ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__a221o_1
XFILLER_0_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3719_ clknet_4_1_0_clk _0166_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_26_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2050_ _0547_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__buf_6
XFILLER_0_76_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2952_ _1163_ _1392_ _1410_ _1083_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_16_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2883_ _0830_ _0835_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__nand2_1
X_1834_ _0289_ _0329_ _0331_ _0332_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__a2bb2o_1
X_1765_ _1751_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__buf_4
XFILLER_0_44_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1903_ _0399_ _0401_ _0282_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_32_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3366_ alu.ALUResult\[27\] reg_file.memory\[10\]\[27\] _1663_ VGND VGND VPWR VPWR
+ _1671_ sky130_fd_sc_hd__mux2_1
X_3504_ reg_file.memory\[25\]\[28\] alu.ALUResult\[28\] _1735_ VGND VGND VPWR VPWR
+ _1744_ sky130_fd_sc_hd__mux2_1
X_3435_ _1707_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3297_ _1634_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__clkbuf_1
X_2317_ _0593_ _0797_ _0801_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2179_ _0575_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__buf_2
X_2248_ _0591_ _0732_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput12 net12 VGND VGND VPWR VPWR cx[2] sky130_fd_sc_hd__buf_1
XFILLER_0_26_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3220_ reg_file.memory\[5\]\[20\] alu.ALUResult\[20\] _1595_ VGND VGND VPWR VPWR
+ _1596_ sky130_fd_sc_hd__mux2_1
X_3151_ _0382_ _0384_ _1545_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__a21o_1
XFILLER_0_27_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2033_ _0516_ _0526_ _0531_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__a21oi_2
X_2102_ reg_file.memory\[15\]\[0\] _0587_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__nand2_1
X_3082_ _1516_ _1517_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__nor2_1
X_2935_ _1363_ _1394_ _0746_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1817_ _0301_ _0302_ _0311_ _0315_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_60_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2866_ _0833_ _1328_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__nor2_1
X_2797_ _0855_ _1252_ _1254_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__a21o_1
XFILLER_0_40_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3349_ alu.ALUResult\[19\] reg_file.memory\[10\]\[19\] _1652_ VGND VGND VPWR VPWR
+ _1662_ sky130_fd_sc_hd__mux2_1
X_3418_ _1698_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_68_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_74_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2582_ _0883_ _0899_ _0725_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__mux2_1
X_2720_ _0877_ _1120_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__nand2_1
X_2651_ _0993_ _1127_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__or2_1
X_3203_ reg_file.memory\[5\]\[12\] alu.ALUResult\[12\] _1584_ VGND VGND VPWR VPWR
+ _1587_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2016_ _0511_ _0514_ _0507_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__a21oi_1
X_3065_ _1505_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__inv_2
X_3134_ _0449_ _0446_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__nand2_1
X_2918_ _0616_ _1378_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2849_ _1292_ _1297_ _1296_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_71_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3752_ clknet_4_3_0_clk _0199_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3683_ clknet_4_10_0_clk _0130_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_2634_ _1016_ _1012_ _0860_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2703_ _0618_ _1176_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__xor2_1
X_2565_ _0976_ _1043_ _1045_ _0929_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__o211a_1
X_2496_ _0698_ _0802_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__or2_1
XFILLER_0_49_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3117_ _1538_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3048_ clk_div.counter\[5\] clk_div.counter\[6\] clk_div.counter\[7\] clk_div.counter\[4\]
+ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__nand4b_1
XFILLER_0_45_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2350_ _0685_ _0834_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__nand2_1
X_2281_ _0765_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_19_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3735_ clknet_4_13_0_clk _0182_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_1996_ alu.ALUResult\[5\] _1753_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__or2_1
XFILLER_0_62_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2617_ _0863_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__clkbuf_4
X_3597_ clk_div.slow_clk _0044_ VGND VGND VPWR VPWR seven_seg_conv.temp\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_7_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2548_ _0996_ _0999_ _1029_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__a21o_1
X_3666_ clknet_4_7_0_clk _0113_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_2479_ _0758_ _0961_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_38_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload0 clknet_4_0_0_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__inv_6
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3520_ _1489_ net4 _0276_ _1485_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__o22a_1
X_1850_ _0341_ _0342_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1781_ alu.ALUResult\[15\] _1752_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__or2_1
XFILLER_0_21_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2333_ _0714_ _0817_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__nand2_1
X_2402_ _0685_ _0800_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__nor2_1
X_3382_ reg_file.memory\[15\]\[2\] alu.ALUResult\[2\] _1677_ VGND VGND VPWR VPWR _1680_
+ sky130_fd_sc_hd__mux2_1
X_3451_ _1716_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2264_ _0714_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2195_ reg_file.memory\[25\]\[14\] _0664_ _0680_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__o21a_1
XFILLER_0_34_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3718_ clknet_4_11_0_clk _0165_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_3649_ clknet_4_9_0_clk _0096_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1979_ _0460_ _0471_ _0476_ _0464_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_30_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_49_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2951_ _1288_ _1409_ _0956_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__mux2_1
X_1902_ _0392_ _0388_ _0400_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3503_ _1743_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__clkbuf_1
X_1764_ _1750_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__buf_4
X_1833_ _0327_ _0330_ _0291_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__nand3_1
X_2882_ _0839_ _0845_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3296_ reg_file.memory\[0\]\[26\] VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__clkbuf_1
X_3365_ _1670_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__clkbuf_1
X_2316_ _0685_ _0800_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__nand2_1
X_3434_ reg_file.memory\[15\]\[27\] alu.ALUResult\[27\] _1699_ VGND VGND VPWR VPWR
+ _1707_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2178_ _0663_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__buf_2
X_2247_ _0660_ _0731_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput13 net13 VGND VGND VPWR VPWR cx[3] sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3150_ _1558_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2032_ _0522_ _0518_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__and2_1
X_2101_ PC\[2\] _0586_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__nor2_1
X_3081_ clk_div.counter\[8\] _1513_ clk_div.counter\[9\] VGND VGND VPWR VPWR _1517_
+ sky130_fd_sc_hd__a21oi_1
X_2934_ _0881_ _0892_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_60_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2865_ _0833_ _1328_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1816_ _0292_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__clkinvlp_2
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2796_ _1254_ _1255_ _1264_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_7_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3348_ _1661_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__clkbuf_1
X_3417_ reg_file.memory\[15\]\[19\] alu.ALUResult\[19\] _1688_ VGND VGND VPWR VPWR
+ _1698_ sky130_fd_sc_hd__mux2_1
X_3279_ _1625_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_67_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2581_ _0766_ _0889_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2650_ _0647_ _0649_ _1073_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__and3_1
XFILLER_0_38_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3202_ _1586_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__clkbuf_1
X_3133_ _1549_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_65_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3064_ clk_div.counter\[3\] clk_div.counter\[4\] _1501_ VGND VGND VPWR VPWR _1505_
+ sky130_fd_sc_hd__and3_1
X_2015_ _0492_ _0512_ _0513_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_19_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2917_ _1325_ _1377_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__or2_1
X_2848_ _1311_ _1312_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__or2b_1
XFILLER_0_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2779_ _1111_ _1117_ _1247_ _1083_ _1248_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__o221a_1
XFILLER_0_0_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3682_ clknet_4_10_0_clk _0129_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_54_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2702_ _0620_ _1153_ _1175_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__a21oi_1
X_3751_ clknet_4_3_0_clk _0198_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_2633_ _0788_ _0866_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__nand2_1
X_2564_ _0976_ _1044_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__nand2_1
X_2495_ _0931_ _0971_ _0975_ _0977_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_65_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3116_ seven_seg_conv.temp\[3\] _1537_ _1534_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__mux2_1
X_3047_ clk_div.counter\[8\] clk_div.counter\[9\] clk_div.counter\[10\] clk_div.counter\[11\]
+ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__or4_1
XFILLER_0_60_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_46 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_23_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2280_ _0725_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_32_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_41_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3734_ clknet_4_13_0_clk _0181_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1995_ _0487_ _0493_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__xnor2_1
X_3665_ clknet_4_6_0_clk _0112_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_2616_ _0766_ _0970_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3596_ clk_div.slow_clk _0043_ VGND VGND VPWR VPWR seven_seg_conv.temp\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_7_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2478_ _0758_ _0961_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__nand2_1
X_2547_ _1027_ _1028_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_50_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload1 clknet_4_1_0_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1780_ _0278_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_12_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2332_ reg_file.memory\[25\]\[24\] _0782_ _0816_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__o21a_1
X_2401_ _0678_ _0792_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__nor2_1
X_3381_ _1679_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__clkbuf_1
X_3450_ reg_file.memory\[25\]\[2\] alu.ALUResult\[2\] _1713_ VGND VGND VPWR VPWR _1716_
+ sky130_fd_sc_hd__mux2_1
X_2263_ _0746_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_46_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2194_ reg_file.memory\[0\]\[14\] _0666_ _0669_ reg_file.memory\[10\]\[14\] _0672_
+ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__a221o_1
XFILLER_0_1_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3717_ clknet_4_11_0_clk _0164_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_3648_ clknet_4_14_0_clk _0095_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_3579_ clknet_4_2_0_clk _0026_ VGND VGND VPWR VPWR clk_div.counter\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1978_ _0464_ _0460_ _0476_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_26_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1832_ _0291_ _0328_ _0330_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__a21o_1
X_2950_ _1347_ _1408_ _0726_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_57_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2881_ _1342_ _1343_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__xnor2_1
X_1901_ _0388_ _0386_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__and2b_1
XFILLER_0_32_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3502_ reg_file.memory\[25\]\[27\] alu.ALUResult\[27\] _1735_ VGND VGND VPWR VPWR
+ _1743_ sky130_fd_sc_hd__mux2_1
X_1763_ seven_seg_conv.digit_counter\[3\] seven_seg_conv.digit_counter\[2\] seven_seg_conv.digit_counter\[0\]
+ seven_seg_conv.digit_counter\[1\] VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__or4_4
X_3433_ _1706_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3295_ _1633_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__clkbuf_1
X_3364_ alu.ALUResult\[26\] reg_file.memory\[10\]\[26\] _1663_ VGND VGND VPWR VPWR
+ _1670_ sky130_fd_sc_hd__mux2_1
X_2315_ _0714_ _0799_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__nand2_1
X_2246_ reg_file.memory\[25\]\[6\] _0663_ _0730_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__o21a_1
XFILLER_0_79_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2177_ _0662_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput14 net14 VGND VGND VPWR VPWR cx[4] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_46_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_54_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2100_ PC\[0\] PC\[1\] VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__and2_1
X_3080_ clk_div.counter\[8\] clk_div.counter\[9\] _1513_ VGND VGND VPWR VPWR _1516_
+ sky130_fd_sc_hd__and3_1
XFILLER_0_76_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2031_ _1757_ _0524_ _0527_ _0529_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__a22o_1
X_1815_ _0313_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__clkinvlp_2
XTAP_TAPCELL_ROW_60_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2864_ _0627_ _1327_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__xnor2_1
X_2933_ _0910_ _0938_ _1151_ _1392_ VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__o211a_1
X_2795_ _1122_ _1256_ _1262_ _1263_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__o211a_1
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3416_ _1697_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3347_ alu.ALUResult\[18\] reg_file.memory\[10\]\[18\] _1652_ VGND VGND VPWR VPWR
+ _1661_ sky130_fd_sc_hd__mux2_1
X_3278_ reg_file.memory\[0\]\[17\] VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__clkbuf_1
X_2229_ _0659_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_75_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_79_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2580_ _1054_ _1059_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3201_ reg_file.memory\[5\]\[11\] alu.ALUResult\[11\] _1584_ VGND VGND VPWR VPWR
+ _1586_ sky130_fd_sc_hd__mux2_1
X_3063_ clk_div.counter\[3\] _1501_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__xor2_1
X_3132_ seven_seg_conv.temp\[8\] _1548_ _1534_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2014_ _0512_ _0504_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2916_ _1354_ _0629_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__and2b_1
X_2847_ _0837_ _1310_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__or2_1
X_2778_ _0957_ _1112_ _1107_ _1118_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_13_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_79_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3681_ clknet_4_11_0_clk _0128_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_3750_ clknet_4_8_0_clk _0197_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2632_ _0579_ _1107_ _1109_ _0777_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__a211o_1
X_2701_ _0993_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__buf_2
X_2563_ _0859_ _0700_ _0726_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__mux2_1
X_2494_ _0976_ _0929_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__nand2_2
XFILLER_0_10_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3046_ clk_div.counter\[0\] clk_div.counter\[1\] VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__or2_1
X_3115_ _0511_ _0514_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1994_ _0489_ _0483_ _0486_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_15_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2615_ _0985_ _0972_ _0726_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__mux2_1
X_3733_ clknet_4_13_0_clk _0180_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3595_ clk_div.slow_clk _0042_ VGND VGND VPWR VPWR seven_seg_conv.temp\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3664_ clknet_4_4_0_clk _0111_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2477_ _0920_ _0960_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__xnor2_1
X_2546_ _0753_ _1026_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_38_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3029_ ctrl_unit.RegWrite VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__inv_2
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload2 clknet_4_3_0_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_18_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2400_ _0789_ _0749_ _0787_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_12_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2331_ reg_file.memory\[0\]\[24\] _0783_ _0784_ reg_file.memory\[10\]\[24\] _0785_
+ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__a221o_1
XFILLER_0_46_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3380_ reg_file.memory\[15\]\[1\] alu.ALUResult\[1\] _1677_ VGND VGND VPWR VPWR _1679_
+ sky130_fd_sc_hd__mux2_1
X_2262_ _0737_ _0745_ _0746_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__mux2_1
X_2193_ _0678_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__buf_4
XFILLER_0_62_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3716_ clknet_4_10_0_clk _0163_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1977_ _0452_ _0462_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__xor2_1
X_3647_ clknet_4_15_0_clk _0094_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_2529_ _0579_ _1004_ _1010_ _0777_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__a211o_1
XFILLER_0_30_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3578_ clknet_4_2_0_clk _0025_ VGND VGND VPWR VPWR clk_div.counter\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_57_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1831_ _0321_ _0322_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__nor2_1
X_2880_ _1324_ _1329_ _1330_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__a21oi_1
X_1900_ _0282_ _0394_ _0398_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3501_ _1742_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__clkbuf_1
X_3363_ _1669_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__clkbuf_1
X_3432_ reg_file.memory\[15\]\[26\] alu.ALUResult\[26\] _1699_ VGND VGND VPWR VPWR
+ _1706_ sky130_fd_sc_hd__mux2_1
X_1762_ PC\[0\] VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__inv_2
X_3294_ reg_file.memory\[0\]\[25\] VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__clkbuf_1
X_2314_ reg_file.memory\[25\]\[29\] _0782_ _0798_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__o21a_1
XFILLER_0_57_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2176_ _0586_ _0238_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__nor2_2
X_2245_ reg_file.memory\[0\]\[6\] _0665_ _0668_ reg_file.memory\[10\]\[6\] _0671_
+ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__a221o_1
XFILLER_0_20_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput15 net15 VGND VGND VPWR VPWR cx[5] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_46_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2030_ _0528_ _0523_ _0525_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__a21bo_1
X_2932_ _0771_ _0869_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1814_ alu.ALUResult\[26\] seven_seg_conv.temp\[26\] _1751_ VGND VGND VPWR VPWR _0313_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2863_ _1325_ _1326_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__or2_1
X_2794_ _0864_ _0776_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3415_ reg_file.memory\[15\]\[18\] alu.ALUResult\[18\] _1688_ VGND VGND VPWR VPWR
+ _1697_ sky130_fd_sc_hd__mux2_1
X_3346_ _1660_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_68_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2159_ _0584_ _0644_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__nand2_1
X_3277_ _1624_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2228_ _0591_ _0712_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_10_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3200_ _1585_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3062_ _1504_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
X_2013_ _0494_ _0496_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__nor2_1
X_3131_ _0462_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__inv_2
XFILLER_0_70_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2915_ _0822_ _1118_ _1123_ _1375_ _0873_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__o221a_1
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2777_ _1106_ _1246_ _0863_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__mux2_1
X_2846_ _0837_ _1310_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3329_ _1651_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3680_ clknet_4_11_0_clk _0127_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_54_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2631_ _0877_ _1006_ _1108_ _0956_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__o211a_1
X_2700_ _0702_ _1155_ _1157_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__a21boi_1
X_2562_ _0747_ _0720_ _0728_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2493_ _0578_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__clkbuf_4
X_3114_ _1536_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
X_3045_ clk_div.counter\[13\] clk_div.counter\[12\] VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2829_ _0651_ _1294_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_1_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3732_ clknet_4_7_0_clk _0179_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_1993_ _0484_ _0490_ _0491_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_15_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2614_ _0579_ _1083_ _1087_ _1092_ _0781_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__o32a_1
XFILLER_0_2_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3594_ clk_div.slow_clk _0041_ VGND VGND VPWR VPWR seven_seg_conv.temp\[0\] sky130_fd_sc_hd__dfxtp_1
X_3663_ clknet_4_6_0_clk _0110_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_2545_ _0753_ _1026_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2476_ _0677_ _0959_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__nor2_1
X_3028_ _1474_ _1475_ _1481_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_38_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload3 clknet_4_4_0_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_21_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2330_ _0685_ _0814_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__nand2_1
X_2261_ _0719_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__clkbuf_4
X_2192_ _0677_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_35_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3715_ clknet_4_10_0_clk _0162_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1976_ _0474_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__inv_2
XFILLER_0_60_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3646_ clknet_4_14_0_clk _0093_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_2528_ _0766_ _1006_ _1007_ _1009_ _0910_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__o221a_1
XFILLER_0_30_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3577_ clknet_4_2_0_clk _0024_ VGND VGND VPWR VPWR clk_div.counter\[3\] sky130_fd_sc_hd__dfxtp_1
X_2459_ _0678_ _0692_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1830_ _0291_ _0328_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__xnor2_1
X_3500_ reg_file.memory\[25\]\[26\] alu.ALUResult\[26\] _1735_ VGND VGND VPWR VPWR
+ _1742_ sky130_fd_sc_hd__mux2_1
X_1761_ seven_seg_conv.digit_counter\[0\] VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__inv_2
XFILLER_0_44_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3362_ alu.ALUResult\[25\] reg_file.memory\[10\]\[25\] _1663_ VGND VGND VPWR VPWR
+ _1669_ sky130_fd_sc_hd__mux2_1
X_2313_ reg_file.memory\[0\]\[29\] _0783_ _0784_ reg_file.memory\[10\]\[29\] _0785_
+ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__a221o_1
X_3431_ _1705_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3293_ _1632_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__clkbuf_1
X_2244_ _0728_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__clkbuf_4
X_2175_ _0660_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_32_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3629_ clknet_4_5_0_clk _0076_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_1959_ _0454_ _0446_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__or2_1
Xoutput16 net16 VGND VGND VPWR VPWR cx[6] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_54_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2931_ _1384_ _1389_ _1390_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_57_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_1813_ _0292_ _0311_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__xnor2_1
X_2862_ _0645_ _0651_ _1293_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__and3_1
X_2793_ _0867_ _1258_ _1261_ _0872_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__o22a_1
X_3345_ alu.ALUResult\[17\] reg_file.memory\[10\]\[17\] _1652_ VGND VGND VPWR VPWR
+ _1660_ sky130_fd_sc_hd__mux2_1
X_3414_ _1696_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__clkbuf_1
X_3276_ reg_file.memory\[0\]\[16\] VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2158_ reg_file.memory\[5\]\[20\] reg_file.memory\[15\]\[20\] _0595_ VGND VGND VPWR
+ VPWR _0644_ sky130_fd_sc_hd__mux2_1
X_2089_ _0574_ PC\[1\] VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__nand2_2
XFILLER_0_17_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2227_ _0659_ _0711_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3130_ _1543_ seven_seg_conv.temp\[7\] _1547_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_65_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3061_ _1497_ _1502_ _1503_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__and3_1
X_2012_ _0501_ _0505_ _0508_ _0509_ _0510_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__a311o_1
XTAP_TAPCELL_ROW_73_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2914_ _0771_ _0869_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__or2_2
X_2845_ _0645_ _1309_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_45_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2776_ _1168_ _1245_ _0860_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3259_ _1615_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__clkbuf_1
X_3328_ alu.ALUResult\[9\] reg_file.memory\[10\]\[9\] _1641_ VGND VGND VPWR VPWR _1651_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2630_ _0726_ _1003_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2561_ _1036_ _0872_ _1037_ _1041_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__a2bb2o_1
X_2492_ _0972_ _0973_ _0974_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__mux2_1
X_3113_ seven_seg_conv.temp\[2\] _0523_ _1534_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3044_ clk_div.counter\[15\] clk_div.counter\[14\] clk_div.counter\[17\] clk_div.counter\[16\]
+ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__or4_1
X_2828_ _1175_ _1293_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2759_ _0976_ _1094_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload10 clknet_4_11_0_clk VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__bufinv_16
X_3731_ clknet_4_7_0_clk _0178_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1992_ _0489_ _0483_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__and2_1
X_3662_ clknet_4_4_0_clk _0109_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2613_ _1091_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__inv_2
XFILLER_0_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3593_ clknet_4_0_0_clk _0040_ VGND VGND VPWR VPWR clk_div.counter\[19\] sky130_fd_sc_hd__dfxtp_1
X_2475_ alu.ALUControl\[1\] alu.ALUControl\[0\] VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__and2_1
X_2544_ _0578_ _1025_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3027_ _1118_ _1111_ _1480_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_38_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload4 clknet_4_5_0_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__inv_6
XFILLER_0_64_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2191_ _0582_ _0588_ _0590_ _0581_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__a31o_2
X_2260_ _0741_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__or2_1
XFILLER_0_62_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3714_ clknet_4_10_0_clk _0161_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_3645_ clknet_4_14_0_clk _0092_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1975_ alu.ALUResult\[7\] seven_seg_conv.temp\[7\] _1753_ VGND VGND VPWR VPWR _0474_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2458_ _0685_ _0682_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__nand2_1
X_2527_ _0748_ _1008_ _0877_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__a21o_1
X_3576_ clknet_4_2_0_clk _0023_ VGND VGND VPWR VPWR clk_div.counter\[2\] sky130_fd_sc_hd__dfxtp_1
X_2389_ _0781_ _0864_ _0867_ _0872_ _0873_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__o221a_1
XFILLER_0_46_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3361_ _1668_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__clkbuf_1
X_3292_ reg_file.memory\[0\]\[24\] VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__clkbuf_1
X_2312_ _0714_ _0796_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__and2_1
X_3430_ reg_file.memory\[15\]\[25\] alu.ALUResult\[25\] _1699_ VGND VGND VPWR VPWR
+ _1705_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2243_ _0582_ _0722_ _0723_ _0581_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__a31oi_4
X_2174_ _0659_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_31_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1889_ _0283_ _0385_ _0387_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__or3_1
Xoutput17 net17 VGND VGND VPWR VPWR cx[7] sky130_fd_sc_hd__buf_1
X_3628_ clknet_4_1_0_clk _0075_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_1958_ _0448_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__clkinvlp_2
X_3559_ clk_div.slow_clk _0001_ VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2930_ _1384_ _1389_ _0868_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__o21ai_1
X_2861_ _1175_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__buf_2
XFILLER_0_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1812_ _0303_ _0307_ _0310_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__a21o_1
X_3413_ reg_file.memory\[15\]\[17\] alu.ALUResult\[17\] _1688_ VGND VGND VPWR VPWR
+ _1696_ sky130_fd_sc_hd__mux2_1
X_2792_ _1192_ _1260_ _0974_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3344_ _1659_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__clkbuf_1
X_3275_ _1623_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__clkbuf_1
X_2226_ reg_file.memory\[25\]\[8\] _0663_ _0710_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__o21a_1
X_2088_ PC\[2\] VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__inv_2
XFILLER_0_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2157_ _0583_ _0642_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_51_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_39_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_48_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_66_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3060_ clk_div.counter\[0\] clk_div.counter\[1\] clk_div.counter\[2\] VGND VGND VPWR
+ VPWR _1503_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_73_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2011_ _0502_ _0504_ _0503_ _0494_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_75_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2913_ _0579_ _1261_ _1373_ _1083_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__a211o_1
X_2844_ _0651_ _1293_ _1175_ VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2775_ _1244_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__inv_2
XFILLER_0_0_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3189_ _1579_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__clkbuf_1
X_2209_ reg_file.memory\[5\]\[1\] _0589_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__nand2_1
X_3258_ reg_file.memory\[0\]\[7\] VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__clkbuf_1
X_3327_ _1650_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_79_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2491_ _0860_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__buf_4
X_2560_ _0956_ _1038_ _1040_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__o21ai_2
X_3043_ _1489_ _1487_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3112_ _1535_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2827_ _0638_ _0657_ _1250_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__and3_1
XFILLER_0_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2758_ _0775_ _1096_ _1088_ _0929_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__a31o_1
X_2689_ _0986_ _0975_ _0910_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2612_ _1088_ _1090_ _0863_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload11 clknet_4_12_0_clk VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__clkinvlp_2
X_3730_ clknet_4_7_0_clk _0177_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3592_ clknet_4_2_0_clk _0039_ VGND VGND VPWR VPWR clk_div.counter\[18\] sky130_fd_sc_hd__dfxtp_1
X_3661_ clknet_4_5_0_clk _0108_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_1991_ _0483_ _0486_ _0489_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__o21ai_1
X_2474_ _0935_ _0938_ _0955_ _0957_ _0868_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__a221o_1
X_2543_ _0866_ _0993_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__nor2_1
X_3026_ _1247_ _1375_ _1479_ _0934_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_38_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload5 clknet_4_6_0_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_0_73_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2190_ _0593_ _0675_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1974_ _0470_ _0472_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__nand2_1
X_3713_ clknet_4_11_0_clk _0160_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_3644_ clknet_4_15_0_clk _0091_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_3575_ clknet_4_0_0_clk _0022_ VGND VGND VPWR VPWR clk_div.counter\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2457_ _0939_ _0940_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__nand2_1
X_2526_ _0922_ _0923_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__nand2_1
X_2388_ _0772_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__clkbuf_4
X_3009_ _1462_ _1463_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3360_ alu.ALUResult\[24\] reg_file.memory\[10\]\[24\] _1663_ VGND VGND VPWR VPWR
+ _1668_ sky130_fd_sc_hd__mux2_1
X_3291_ _1631_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__clkbuf_1
X_2311_ reg_file.memory\[25\]\[28\] _0782_ _0795_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__o21a_1
XFILLER_0_57_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2242_ _0700_ _0721_ _0726_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2173_ _0632_ _0639_ _0658_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__and3_2
XFILLER_0_7_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1957_ _0453_ _0455_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1888_ _0379_ _0382_ _0384_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__and3_1
X_2509_ _0781_ _0987_ _0991_ _0872_ _0873_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__o221a_1
X_3558_ clk_div.slow_clk _0000_ VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__dfxtp_1
X_3627_ clknet_4_4_0_clk _0074_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3489_ _1736_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1811_ _0308_ _0309_ _0297_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__o21a_1
X_2860_ _1312_ _1314_ _1311_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_43_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2791_ _1224_ _1259_ _0719_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__mux2_1
X_3412_ _1695_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3343_ alu.ALUResult\[16\] reg_file.memory\[10\]\[16\] _1652_ VGND VGND VPWR VPWR
+ _1659_ sky130_fd_sc_hd__mux2_1
X_3274_ reg_file.memory\[0\]\[15\] VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__clkbuf_1
X_2225_ reg_file.memory\[0\]\[8\] _0665_ _0668_ reg_file.memory\[10\]\[8\] _0671_
+ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__a221o_1
XFILLER_0_75_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2087_ _0239_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__inv_2
XFILLER_0_17_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2156_ reg_file.memory\[5\]\[8\] reg_file.memory\[15\]\[8\] _0594_ VGND VGND VPWR
+ VPWR _0642_ sky130_fd_sc_hd__mux2_1
X_2989_ _0799_ _1444_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_51_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2010_ _0502_ _0503_ _0494_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__a21oi_1
X_2912_ _0729_ _1371_ _1372_ _1096_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__o211a_1
X_2774_ _0921_ _1242_ _1243_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__o21ai_1
X_2843_ _0968_ _1300_ _1308_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3326_ alu.ALUResult\[8\] reg_file.memory\[10\]\[8\] _1641_ VGND VGND VPWR VPWR _1650_
+ sky130_fd_sc_hd__mux2_1
X_2139_ _0584_ _0624_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__nand2_1
X_2208_ _0686_ _0689_ _0693_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__o21ai_1
X_3188_ reg_file.memory\[5\]\[5\] alu.ALUResult\[5\] _1573_ VGND VGND VPWR VPWR _1579_
+ sky130_fd_sc_hd__mux2_1
X_3257_ _1614_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2490_ _0694_ _0708_ _0746_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__mux2_1
X_3111_ seven_seg_conv.temp\[1\] _1533_ _1534_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__mux2_1
X_3042_ _0544_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__buf_4
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2757_ _1087_ _1227_ _0910_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__mux2_1
X_2826_ _1281_ _1284_ _1280_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__a21oi_1
X_2688_ _0990_ _1162_ _0863_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3309_ _1640_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_1_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1990_ _0487_ _0482_ _0488_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__or3_1
X_2611_ _0980_ _1089_ _0725_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__mux2_1
Xclkload12 clknet_4_13_0_clk VGND VGND VPWR VPWR clkload12/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_42_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2542_ _0781_ _1020_ _1023_ _0872_ _0772_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__o221a_1
X_3660_ clknet_4_4_0_clk _0107_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3591_ clknet_4_3_0_clk _0038_ VGND VGND VPWR VPWR clk_div.counter\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2473_ _0956_ _0776_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__nor2_1
X_3025_ _0910_ _1365_ _1478_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_73_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload6 clknet_4_7_0_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__clkinv_1
X_3789_ clk_div.slow_clk _0236_ VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__dfxtp_1
X_2809_ _0777_ _0911_ _1276_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_6_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3712_ clknet_4_11_0_clk _0159_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1973_ _0464_ _0460_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__nand3_1
X_3643_ clknet_4_14_0_clk _0090_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_2525_ _0748_ _0918_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3574_ clknet_4_2_0_clk _0021_ VGND VGND VPWR VPWR clk_div.counter\[0\] sky130_fd_sc_hd__dfxtp_1
X_2387_ _0871_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__buf_2
XFILLER_0_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2456_ _0789_ _0675_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__nand2_1
X_3008_ _1442_ _1446_ _1445_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__o21a_1
XFILLER_0_61_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2310_ reg_file.memory\[0\]\[28\] _0783_ _0784_ reg_file.memory\[10\]\[28\] _0785_
+ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__a221o_1
X_3290_ reg_file.memory\[0\]\[23\] VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__clkbuf_1
X_2241_ _0725_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_57_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2172_ _0641_ _0643_ _0652_ _0657_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__and4_1
XFILLER_0_75_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1887_ _0378_ _0385_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__xor2_1
XFILLER_0_43_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1956_ _0443_ _0454_ _0446_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__o21ai_1
X_3557_ _0265_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[31\] sky130_fd_sc_hd__dlxtn_1
X_3488_ reg_file.memory\[25\]\[20\] alu.ALUResult\[20\] _1735_ VGND VGND VPWR VPWR
+ _1736_ sky130_fd_sc_hd__mux2_1
X_2508_ _0990_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__inv_2
XFILLER_0_43_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3626_ clknet_4_3_0_clk _0073_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_2439_ _0593_ _0740_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_54_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1810_ _0304_ _0299_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2790_ _0857_ _0676_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3411_ reg_file.memory\[15\]\[16\] alu.ALUResult\[16\] _1688_ VGND VGND VPWR VPWR
+ _1695_ sky130_fd_sc_hd__mux2_1
X_3342_ _1658_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__clkbuf_1
X_3273_ _1622_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2155_ _0583_ _0640_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__nand2_1
X_2224_ _0708_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_51_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2086_ PC\[2\] PC\[0\] VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__nand2_1
X_2988_ _0636_ _1443_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__xnor2_1
X_3609_ clk_div.slow_clk _0056_ VGND VGND VPWR VPWR seven_seg_conv.temp\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1939_ _1760_ _0433_ _0432_ _0436_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2911_ _0729_ _1318_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2842_ _1023_ _1258_ _1306_ _1307_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__o211a_1
X_2773_ _0698_ _1208_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3256_ reg_file.memory\[0\]\[6\] VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__clkbuf_1
X_3325_ _1649_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__clkbuf_1
X_2138_ reg_file.memory\[5\]\[22\] reg_file.memory\[15\]\[22\] _0603_ VGND VGND VPWR
+ VPWR _0624_ sky130_fd_sc_hd__mux2_1
X_2207_ _0593_ _0692_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__nand2_1
X_2069_ _0560_ _0561_ _0562_ _0557_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__a22o_1
X_3187_ _1578_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3110_ _0544_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__clkbuf_4
X_3041_ _1487_ _1488_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2825_ _1134_ _1285_ _1291_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2756_ _0729_ _1161_ _1226_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__a21oi_1
X_2687_ _1085_ _1161_ _0860_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3239_ _1605_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__clkbuf_1
X_3308_ PC\[2\] PC\[0\] PC\[1\] _0008_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__or4_4
XFILLER_0_76_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2610_ _0984_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__inv_2
X_2472_ _0863_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__clkbuf_4
Xclkload13 clknet_4_14_0_clk VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_42_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2541_ _0877_ _1022_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__or2_1
X_3590_ clknet_4_2_0_clk _0037_ VGND VGND VPWR VPWR clk_div.counter\[16\] sky130_fd_sc_hd__dfxtp_1
X_3024_ _0877_ _1422_ _1477_ _0578_ VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__a211o_1
XFILLER_0_25_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3788_ clk_div.slow_clk _0235_ VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__dfxtp_1
Xclkload7 clknet_4_8_0_clk VGND VGND VPWR VPWR clkload7/Y sky130_fd_sc_hd__clkinvlp_4
X_2808_ _1150_ _1256_ _1274_ _0872_ _1275_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__o221a_1
XFILLER_0_26_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2739_ _1067_ _1210_ _0956_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_37_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3711_ clknet_4_10_0_clk _0158_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_3642_ clknet_4_15_0_clk _0089_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1972_ _0466_ _0468_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__and2_1
X_3573_ clk_div.slow_clk _0019_ VGND VGND VPWR VPWR seven_seg_conv.digit_counter\[3\]
+ sky130_fd_sc_hd__dfxtp_4
XFILLER_0_70_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2455_ _0686_ _0856_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__nand2_1
X_2524_ _0748_ _0915_ _1005_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_11_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2386_ _0863_ _0870_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__nand2_1
X_3007_ _1460_ _1461_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2171_ _0654_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2240_ _0724_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_28_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1886_ _0382_ _0384_ _0379_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3625_ clknet_4_1_0_clk _0072_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1955_ _1759_ _0448_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__or2_1
X_3487_ _1712_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__clkbuf_4
X_3556_ _0264_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[30\] sky130_fd_sc_hd__dlxtn_2
XFILLER_0_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2507_ _0728_ _0989_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__nor2_1
X_2438_ _0679_ _0754_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__nand2_1
X_2369_ reg_file.memory\[0\]\[16\] _0666_ _0669_ reg_file.memory\[10\]\[16\] _0672_
+ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__a221o_1
XFILLER_0_78_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3341_ alu.ALUResult\[15\] reg_file.memory\[10\]\[15\] _1652_ VGND VGND VPWR VPWR
+ _1658_ sky130_fd_sc_hd__mux2_1
X_3410_ _1694_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__clkbuf_1
X_3272_ reg_file.memory\[0\]\[14\] VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__clkbuf_1
X_2223_ _0704_ _0707_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__nor2_1
X_2085_ _0572_ _0567_ _0561_ _0573_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__a2bb2o_1
X_2154_ reg_file.memory\[5\]\[9\] reg_file.memory\[15\]\[9\] _0594_ VGND VGND VPWR
+ VPWR _0640_ sky130_fd_sc_hd__mux2_1
X_2987_ _0611_ _1325_ _1426_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_51_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1869_ _0354_ _0359_ _0366_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__o21ai_1
X_3608_ clk_div.slow_clk _0055_ VGND VGND VPWR VPWR seven_seg_conv.temp\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1938_ _0425_ _0436_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__xor2_2
XFILLER_0_16_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3539_ _0245_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[13\] sky130_fd_sc_hd__dlxtn_1
XPHY_EDGE_ROW_26_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_35_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2910_ _1346_ _1370_ _0906_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2841_ _0776_ _1020_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__or2_1
X_2772_ _0940_ _0942_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_44_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2206_ _0660_ _0691_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3255_ _1613_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__clkbuf_1
X_3324_ alu.ALUResult\[7\] reg_file.memory\[10\]\[7\] _1641_ VGND VGND VPWR VPWR _1649_
+ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_53_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2137_ _0584_ _0622_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__nand2_1
X_2068_ _0010_ _0009_ _0555_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__o21a_1
X_3186_ reg_file.memory\[5\]\[4\] alu.ALUResult\[4\] _1573_ VGND VGND VPWR VPWR _1578_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_62_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_71_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_70_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3040_ seven_seg_conv.digit_counter\[0\] seven_seg_conv.digit_counter\[1\] seven_seg_conv.digit_counter\[2\]
+ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_65_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2824_ _0777_ _0987_ _1290_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2755_ _0728_ _1225_ VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2686_ _1119_ _1160_ _0888_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3169_ seven_seg_conv.temp\[25\] _1568_ _0544_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__mux2_1
X_3307_ _1639_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__clkbuf_1
X_3238_ reg_file.memory\[5\]\[29\] alu.ALUResult\[29\] _1595_ VGND VGND VPWR VPWR
+ _1605_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload14 clknet_4_15_0_clk VGND VGND VPWR VPWR clkload14/Y sky130_fd_sc_hd__inv_6
XFILLER_0_50_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2471_ _0946_ _0954_ _0766_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__mux2_1
X_2540_ _0936_ _1021_ _0719_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3023_ _0906_ _1451_ _1476_ _0860_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__o211a_1
X_3787_ clk_div.slow_clk _0234_ VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload8 clknet_4_9_0_clk VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__inv_6
X_2738_ _1149_ _1209_ _0765_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2807_ _0729_ _0937_ _1258_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__or3_1
XFILLER_0_26_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2669_ _1130_ _1139_ _1144_ _0772_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__a31o_1
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_29_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3572_ clk_div.slow_clk _0018_ VGND VGND VPWR VPWR seven_seg_conv.digit_counter\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_3710_ clknet_4_10_0_clk _0157_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_3641_ clknet_4_15_0_clk _0088_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1971_ _0460_ _0469_ _0464_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__a21o_1
XFILLER_0_23_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2454_ _0729_ _0937_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__nor2_1
X_2523_ _0906_ _0949_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__nor2_1
X_2385_ _0780_ _0869_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__nor2_2
X_3006_ _0791_ _1459_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__or2_1
Xinput1 next VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_36_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2170_ _0584_ _0655_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1954_ _1759_ _0443_ _0446_ _0450_ _0452_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__a311o_1
X_3555_ _0262_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[29\] sky130_fd_sc_hd__dlxtn_2
X_1885_ _0371_ _0376_ _0381_ _0383_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__o211ai_2
X_3624_ clknet_4_1_0_clk _0071_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3486_ _1734_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2368_ _0749_ _0852_ _0789_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2437_ _0920_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__clkbuf_4
X_2506_ _0763_ _0988_ _0746_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__mux2_1
X_2299_ _0669_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3340_ _1657_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__clkbuf_1
X_2222_ _0592_ _0660_ _0706_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__and3_1
X_3271_ _1621_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_76_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2153_ _0634_ _0636_ _0638_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__and3_1
X_2084_ _0010_ _0011_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__xor2_1
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2986_ _1429_ _1432_ _1428_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_63_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1937_ _0429_ _0432_ _1760_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__a21oi_2
X_1799_ alu.ALUResult\[29\] alu.ALUResult\[30\] _1750_ alu.ALUResult\[31\] VGND VGND
+ VPWR VPWR _0298_ sky130_fd_sc_hd__or4b_1
X_1868_ _0354_ _0366_ _0359_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__or3_1
X_3607_ clk_div.slow_clk _0054_ VGND VGND VPWR VPWR seven_seg_conv.temp\[13\] sky130_fd_sc_hd__dfxtp_1
X_3538_ _0244_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[12\] sky130_fd_sc_hd__dlxtn_1
XFILLER_0_24_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3469_ reg_file.memory\[25\]\[11\] alu.ALUResult\[11\] _1724_ VGND VGND VPWR VPWR
+ _1726_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2840_ _0976_ _1169_ _1305_ _0934_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__a211o_1
X_2771_ _1218_ _1222_ _1238_ _1240_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2205_ reg_file.memory\[25\]\[13\] _0664_ _0690_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__o21a_1
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3254_ reg_file.memory\[0\]\[5\] VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__clkbuf_1
X_3323_ _1648_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__clkbuf_1
X_3185_ _1577_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_64_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2136_ reg_file.memory\[5\]\[15\] reg_file.memory\[15\]\[15\] _0595_ VGND VGND VPWR
+ VPWR _0622_ sky130_fd_sc_hd__mux2_1
X_2067_ _0009_ _0012_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__and2_1
X_2969_ _0634_ _0607_ _1400_ _1325_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__a31o_1
XFILLER_0_12_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2823_ _0991_ _1258_ _1288_ _0872_ _1289_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__o221a_1
XFILLER_0_45_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2754_ _1191_ _1224_ _0888_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3306_ reg_file.memory\[0\]\[31\] VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2685_ _1159_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_18_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3168_ _0318_ _0320_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__nand2_1
X_3237_ _1604_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__clkbuf_1
X_2119_ _0585_ _0604_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3099_ clk_div.counter\[15\] _1527_ clk_div.counter\[16\] VGND VGND VPWR VPWR _1528_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_0_32_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2470_ _0921_ _0949_ _0953_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__o21ai_1
X_3022_ _0921_ _0884_ _0885_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__or3_1
XFILLER_0_58_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3786_ clk_div.slow_clk _0233_ VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload9 clknet_4_10_0_clk VGND VGND VPWR VPWR clkload9/X sky130_fd_sc_hd__clkbuf_4
X_2806_ _1209_ _1273_ _0765_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2737_ _1167_ _1208_ _0746_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2668_ _1142_ _1143_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__nand2_1
X_2599_ _1076_ _1077_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_37_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1970_ _0463_ _0464_ _0466_ _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__a2bb2o_1
X_3571_ clk_div.slow_clk _0017_ VGND VGND VPWR VPWR seven_seg_conv.digit_counter\[1\]
+ sky130_fd_sc_hd__dfxtp_1
X_3640_ clknet_4_13_0_clk _0087_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_2522_ _1002_ _1003_ _0766_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2453_ _0921_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__or2_1
X_2384_ alu.ALUControl\[0\] _0868_ _0774_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__or3b_2
Xinput2 rst VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_2
X_3005_ _0791_ _1459_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3769_ clknet_4_12_0_clk _0216_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_48_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1884_ _0371_ _0374_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1953_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__clkbuf_2
X_3554_ _0261_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[28\] sky130_fd_sc_hd__dlxtn_2
X_3485_ reg_file.memory\[25\]\[19\] alu.ALUResult\[19\] _1724_ VGND VGND VPWR VPWR
+ _1734_ sky130_fd_sc_hd__mux2_1
X_3623_ clknet_4_1_0_clk _0070_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2505_ _0678_ _0661_ _0751_ _0759_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_22_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2298_ _0666_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_47_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2367_ reg_file.memory\[25\]\[17\] _0664_ _0851_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__o21a_1
XFILLER_0_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2436_ _0582_ _0695_ _0696_ _0240_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_66_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2152_ _0584_ _0637_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__nand2_1
X_3270_ reg_file.memory\[0\]\[13\] VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__clkbuf_1
X_2221_ reg_file.memory\[25\]\[11\] _0663_ _0705_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_76_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2083_ _0010_ _0012_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__or2_1
X_2985_ _0968_ _1433_ _1434_ _1441_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__o22a_1
X_1867_ _0344_ _0353_ _0350_ _0351_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__a31o_1
XFILLER_0_33_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1936_ _0429_ _0434_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__and2_1
X_1798_ alu.ALUResult\[28\] _0295_ _0296_ _0279_ alu.ALUResult\[30\] VGND VGND VPWR
+ VPWR _0297_ sky130_fd_sc_hd__o2111ai_4
XFILLER_0_58_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3537_ _0243_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[11\] sky130_fd_sc_hd__dlxtn_1
X_3606_ clk_div.slow_clk _0053_ VGND VGND VPWR VPWR seven_seg_conv.temp\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3468_ _1725_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__clkbuf_1
X_2419_ _0685_ _0848_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__nand2_1
X_3399_ reg_file.memory\[15\]\[10\] alu.ALUResult\[10\] _1688_ VGND VGND VPWR VPWR
+ _1689_ sky130_fd_sc_hd__mux2_1
XFILLER_0_66_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2770_ _0868_ _1239_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3322_ alu.ALUResult\[6\] reg_file.memory\[10\]\[6\] _1641_ VGND VGND VPWR VPWR _1648_
+ sky130_fd_sc_hd__mux2_1
X_2204_ reg_file.memory\[0\]\[13\] _0666_ _0669_ reg_file.memory\[10\]\[13\] _0672_
+ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__a221o_1
X_2135_ _0618_ _0620_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__and2_1
XFILLER_0_28_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3253_ _1612_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__clkbuf_1
X_3184_ reg_file.memory\[5\]\[3\] alu.ALUResult\[3\] _1573_ VGND VGND VPWR VPWR _1577_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_64_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2066_ _0010_ _0011_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__nor2b_1
XFILLER_0_8_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2968_ _0931_ _1018_ _1413_ _1425_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__a211o_1
XFILLER_0_60_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2899_ _1357_ _1359_ _1353_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_56_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1919_ _0275_ _0414_ _0416_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_4_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2822_ _1256_ _1162_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__or2b_1
X_2753_ _0683_ _0693_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2684_ _0704_ _0717_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__nor2_1
X_3305_ _1638_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__clkbuf_1
X_3167_ _1567_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__clkbuf_1
X_2118_ reg_file.memory\[5\]\[31\] reg_file.memory\[15\]\[31\] _0603_ VGND VGND VPWR
+ VPWR _0604_ sky130_fd_sc_hd__mux2_1
X_3236_ reg_file.memory\[5\]\[28\] alu.ALUResult\[28\] _1595_ VGND VGND VPWR VPWR
+ _1604_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2049_ seven_seg_conv.current_digit\[0\] _0546_ _0543_ VGND VGND VPWR VPWR _0547_
+ sky130_fd_sc_hd__mux2_1
X_3098_ clk_div.counter\[15\] _1527_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__xor2_1
XFILLER_0_71_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3021_ _1460_ _1465_ _1473_ _0873_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__a31o_1
XFILLER_0_73_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2805_ _1242_ _1272_ _0746_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__mux2_1
X_3785_ clk_div.slow_clk _0232_ VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2736_ _0943_ _0951_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__nand2_1
X_2667_ _0716_ _1141_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__or2_1
X_3219_ _1572_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2598_ _0731_ _1075_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_37_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3570_ clk_div.slow_clk _0016_ VGND VGND VPWR VPWR seven_seg_conv.digit_counter\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2521_ _0944_ _0952_ _0888_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2452_ _0679_ _0762_ _0925_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2383_ alu.ALUControl\[1\] alu.ALUControl\[2\] VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__nand2b_4
X_3004_ _0609_ _1458_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3768_ clknet_4_12_0_clk _0215_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_34_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2719_ _1159_ _1191_ _0906_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__mux2_1
X_3699_ clknet_4_7_0_clk _0146_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_57_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3622_ clk_div.slow_clk _0069_ VGND VGND VPWR VPWR seven_seg_conv.temp\[28\] sky130_fd_sc_hd__dfxtp_1
X_1883_ _0378_ _0379_ _0380_ _0381_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_28_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1952_ alu.ALUResult\[9\] seven_seg_conv.temp\[9\] _1752_ VGND VGND VPWR VPWR _0451_
+ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3553_ _0260_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[27\] sky130_fd_sc_hd__dlxtn_1
XFILLER_0_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3484_ _1733_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__clkbuf_1
X_2504_ _0983_ _0986_ _0956_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__mux2_1
X_2435_ _0915_ _0918_ _0906_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2297_ _0664_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__buf_2
X_2366_ reg_file.memory\[0\]\[17\] _0666_ _0669_ reg_file.memory\[10\]\[17\] _0672_
+ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__a221o_1
XFILLER_0_66_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2151_ reg_file.memory\[5\]\[18\] reg_file.memory\[15\]\[18\] _0595_ VGND VGND VPWR
+ VPWR _0637_ sky130_fd_sc_hd__mux2_1
X_2220_ reg_file.memory\[0\]\[11\] _0665_ _0668_ reg_file.memory\[10\]\[11\] _0671_
+ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__a221o_1
X_2082_ _0570_ _0562_ _0571_ _0569_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2984_ _1435_ _1440_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1797_ alu.ALUResult\[29\] alu.ALUResult\[31\] VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__or2b_1
X_1866_ _0363_ _0364_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__nor2_1
X_1935_ _0430_ _0432_ _0433_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__o21ai_1
X_3605_ clk_div.slow_clk _0052_ VGND VGND VPWR VPWR seven_seg_conv.temp\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2418_ _0900_ _0901_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3398_ _1676_ VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__clkbuf_4
X_3536_ _0242_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[10\] sky130_fd_sc_hd__dlxtn_1
X_3467_ reg_file.memory\[25\]\[10\] alu.ALUResult\[10\] _1724_ VGND VGND VPWR VPWR
+ _1725_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2349_ _0660_ _0833_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_50_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3321_ _1647_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__clkbuf_1
X_3252_ reg_file.memory\[0\]\[4\] VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_64_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2203_ _0659_ _0688_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__and2_1
X_2134_ _0583_ _0619_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2065_ _0555_ _0556_ _0557_ _0558_ _0559_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__a32o_1
X_3183_ _1576_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__clkbuf_1
X_2967_ _1134_ _1420_ _1424_ _0870_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__a22o_1
XFILLER_0_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_22_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1849_ _0343_ _0344_ _0346_ _0347_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__o211ai_2
X_2898_ _1353_ _1357_ _1359_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__and3_1
X_1918_ _0414_ _0416_ _0275_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_31_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3519_ _1489_ net5 _0276_ _1486_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__o22a_1
XFILLER_0_5_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2821_ _1225_ _1287_ _0860_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2752_ _1221_ _1220_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__or2b_1
X_2683_ _1142_ _1146_ _1156_ _0873_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__a31oi_1
X_3304_ reg_file.memory\[0\]\[30\] VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__clkbuf_1
X_3235_ _1603_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__clkbuf_1
X_3166_ seven_seg_conv.temp\[24\] _0328_ _0544_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__mux2_1
X_2117_ _0595_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__clkbuf_4
X_2048_ alu.ALUResult\[0\] seven_seg_conv.temp\[0\] _1753_ VGND VGND VPWR VPWR _0546_
+ sky130_fd_sc_hd__mux2_1
X_3097_ clk_div.counter\[13\] clk_div.counter\[14\] _1521_ VGND VGND VPWR VPWR _1527_
+ sky130_fd_sc_hd__and3_1
XFILLER_0_44_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3020_ _1460_ _1465_ _1473_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__a21oi_1
X_3784_ clk_div.slow_clk _0231_ VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__dfxtp_1
X_2804_ _0904_ _0939_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2735_ _1200_ _1206_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__xnor2_1
X_2666_ _0716_ _1141_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__nand2_1
X_2597_ _0731_ _1075_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3218_ _1594_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__clkbuf_1
X_3149_ seven_seg_conv.temp\[16\] _0393_ _0544_ VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2451_ _0578_ _0934_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__nor2_1
X_2520_ _0905_ _0941_ _0746_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3003_ _0636_ _1325_ _1443_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_36_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2382_ _0762_ _0866_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3767_ clknet_4_12_0_clk _0214_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_2718_ _0679_ _0689_ _0707_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__a21oi_1
X_2649_ _0735_ _1100_ _1102_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__a21o_1
X_3698_ clknet_4_7_0_clk _0145_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_20_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_69_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_78_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3621_ clk_div.slow_clk _0068_ VGND VGND VPWR VPWR seven_seg_conv.temp\[27\] sky130_fd_sc_hd__dfxtp_1
X_3552_ _0259_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[26\] sky130_fd_sc_hd__dlxtn_1
X_1882_ _0374_ _0376_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_31_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1951_ _0449_ _0446_ _1759_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__a21oi_1
X_2365_ _0845_ _0849_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__nand2_1
X_2503_ _0984_ _0985_ _0726_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__mux2_1
X_3483_ reg_file.memory\[25\]\[18\] alu.ALUResult\[18\] _1724_ VGND VGND VPWR VPWR
+ _1733_ sky130_fd_sc_hd__mux2_1
X_2434_ _0686_ _0916_ _0917_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__o21a_1
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2296_ _0780_ _0775_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__nand2_2
XFILLER_0_2_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_76_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2150_ _0585_ _0635_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__nand2_1
X_2081_ _0009_ _0011_ _0012_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__o21a_1
X_2983_ _1118_ _1038_ _1439_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_33_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1934_ _0427_ _0428_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__nand2_1
X_1796_ _0293_ _0294_ _1750_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__a21oi_2
X_1865_ alu.ALUResult\[20\] seven_seg_conv.temp\[20\] _1751_ VGND VGND VPWR VPWR _0364_
+ sky130_fd_sc_hd__mux2_1
X_3535_ _0272_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[9\] sky130_fd_sc_hd__dlxtn_1
XFILLER_0_31_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3604_ clk_div.slow_clk _0051_ VGND VGND VPWR VPWR seven_seg_conv.temp\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2417_ _0789_ _0844_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__nand2_1
X_2348_ reg_file.memory\[25\]\[21\] _0664_ _0832_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__o21a_1
X_3466_ _1712_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3397_ _1687_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2279_ _0748_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2202_ reg_file.memory\[25\]\[12\] _0663_ _0687_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__o21a_1
X_3320_ alu.ALUResult\[5\] reg_file.memory\[10\]\[5\] _1641_ VGND VGND VPWR VPWR _1647_
+ sky130_fd_sc_hd__mux2_1
X_3251_ _1611_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3182_ reg_file.memory\[5\]\[2\] alu.ALUResult\[2\] _1573_ VGND VGND VPWR VPWR _1576_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2133_ reg_file.memory\[5\]\[10\] reg_file.memory\[15\]\[10\] _0594_ VGND VGND VPWR
+ VPWR _0619_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2064_ _0012_ _0011_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__and2_1
X_2966_ _1304_ _1423_ _0910_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2897_ _1358_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__inv_2
X_1917_ _0404_ _0405_ _0415_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__a21bo_1
X_3518_ _0016_ _0277_ _0276_ net6 _1489_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__o32a_1
X_1779_ _0276_ _0277_ _0016_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__and3b_1
XFILLER_0_71_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1848_ _0288_ _0342_ _0345_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_4_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3449_ _1715_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2820_ _1259_ _1286_ _0888_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__mux2_1
X_2751_ _1220_ _1221_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__or2b_1
XFILLER_0_5_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2682_ _1142_ _1146_ _1156_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__a21o_1
X_3303_ _1637_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__clkbuf_1
X_3165_ _1566_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__clkbuf_1
X_3234_ reg_file.memory\[5\]\[27\] alu.ALUResult\[27\] _1595_ VGND VGND VPWR VPWR
+ _1603_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2116_ _0584_ _0601_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__nand2_1
X_2047_ _0545_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__buf_4
X_3096_ clk_div.counter\[14\] _1525_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__xnor2_1
X_2949_ _1370_ _1407_ _0699_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3783_ clk_div.slow_clk _0230_ VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__dfxtp_1
X_2803_ _1268_ _1269_ _1265_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__a21o_1
XFILLER_0_41_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2734_ _1203_ _1205_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2665_ _0641_ _1140_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2596_ _0649_ _1074_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3217_ reg_file.memory\[5\]\[19\] alu.ALUResult\[19\] _1584_ VGND VGND VPWR VPWR
+ _1594_ sky130_fd_sc_hd__mux2_1
X_3148_ _1543_ seven_seg_conv.temp\[15\] _1557_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3079_ clk_div.counter\[8\] _1513_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_20_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2450_ _0933_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__buf_2
X_2381_ _0865_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__buf_2
XFILLER_0_78_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3002_ _1228_ _1375_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3766_ clknet_4_12_0_clk _0213_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_2717_ _1187_ _1188_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__or2_1
XFILLER_0_14_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3697_ clknet_4_6_0_clk _0144_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_2648_ _0861_ _0977_ _1117_ _0822_ _1124_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__o221ai_2
X_2579_ _1057_ _1058_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__or2b_1
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1950_ _1759_ _0448_ _0443_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__o21bai_1
X_3620_ clk_div.slow_clk _0067_ VGND VGND VPWR VPWR seven_seg_conv.temp\[26\] sky130_fd_sc_hd__dfxtp_1
X_3551_ _0258_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[25\] sky130_fd_sc_hd__dlxtn_1
X_2502_ _0840_ _0850_ _0699_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__mux2_1
X_1881_ _0372_ _0373_ _0377_ _0286_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_31_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2364_ _0679_ _0848_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__nand2_1
X_3482_ _1732_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__clkbuf_1
X_2433_ _0593_ _0732_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2295_ _0779_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__buf_2
XFILLER_0_6_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3749_ clknet_4_8_0_clk _0196_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_76_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2080_ _0010_ _0009_ _0011_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2982_ _0729_ _1371_ _1438_ _0871_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__a211o_1
X_1933_ _0431_ _0419_ _0420_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__mux2_2
XFILLER_0_16_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1795_ alu.ALUResult\[29\] alu.ALUResult\[30\] alu.ALUResult\[31\] VGND VGND VPWR
+ VPWR _0294_ sky130_fd_sc_hd__nand3b_1
X_1864_ _0354_ _0359_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__xnor2_1
X_3465_ _1723_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__clkbuf_1
X_3603_ clk_div.slow_clk _0050_ VGND VGND VPWR VPWR seven_seg_conv.temp\[9\] sky130_fd_sc_hd__dfxtp_1
X_3534_ _0271_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[8\] sky130_fd_sc_hd__dlxtn_1
X_2416_ _0685_ _0838_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2347_ reg_file.memory\[0\]\[21\] _0666_ _0669_ reg_file.memory\[10\]\[21\] _0672_
+ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__a221o_1
XFILLER_0_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2278_ _0679_ _0762_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__nand2_1
X_3396_ reg_file.memory\[15\]\[9\] alu.ALUResult\[9\] _1677_ VGND VGND VPWR VPWR _1687_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2132_ _0583_ _0617_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__nand2_1
X_2201_ reg_file.memory\[0\]\[12\] _0665_ _0668_ reg_file.memory\[10\]\[12\] _0671_
+ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__a221o_1
XFILLER_0_28_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3181_ _1575_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__clkbuf_1
X_3250_ reg_file.memory\[0\]\[3\] VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2063_ _0010_ _0009_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__nor2_1
X_1847_ _0288_ _0345_ _0342_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__nand3_1
X_2965_ _1364_ _1422_ _0765_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2896_ _0824_ _1356_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1916_ _0408_ _0405_ _0412_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__o21a_1
X_3517_ seven_seg_conv.digit_counter\[0\] seven_seg_conv.digit_counter\[1\] _1749_
+ net7 _1489_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__o32a_1
X_1778_ seven_seg_conv.digit_counter\[1\] VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__inv_2
X_3448_ reg_file.memory\[25\]\[1\] alu.ALUResult\[1\] _1713_ VGND VGND VPWR VPWR _1715_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3379_ _1678_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2750_ _1200_ _1203_ _1204_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__a21oi_1
X_2681_ _0702_ _1155_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3302_ reg_file.memory\[0\]\[29\] VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3164_ seven_seg_conv.temp\[23\] _1565_ _0544_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__mux2_1
X_3233_ _1602_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__clkbuf_1
X_2115_ reg_file.memory\[5\]\[14\] reg_file.memory\[15\]\[14\] _0595_ VGND VGND VPWR
+ VPWR _0601_ sky130_fd_sc_hd__mux2_1
X_3095_ _1526_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2046_ seven_seg_conv.current_digit\[1\] _0542_ _0544_ VGND VGND VPWR VPWR _0545_
+ sky130_fd_sc_hd__mux2_1
X_2948_ _0810_ _0815_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__nand2_1
X_2879_ _0828_ _1341_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3782_ clknet_4_11_0_clk _0229_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_2802_ _1265_ _1268_ _1269_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__nand3_1
XFILLER_0_41_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2733_ _1204_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__inv_2
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2664_ _0643_ _1127_ _0993_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2595_ _0993_ _1073_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__or2_1
XFILLER_0_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3216_ _1593_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__clkbuf_1
X_3147_ _0399_ _0401_ _1545_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__a21oi_1
X_3078_ _1515_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
X_2029_ _1758_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__inv_2
XFILLER_0_17_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2380_ _0724_ _0697_ _0677_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__and3_1
X_3001_ _1449_ _1450_ _1456_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_59_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3765_ clknet_4_12_0_clk _0212_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_2716_ _1187_ _1188_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__nand2_1
X_2647_ _1118_ _0727_ _1123_ _0934_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__o22a_1
XFILLER_0_14_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3696_ clknet_4_4_0_clk _0143_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_2578_ _0743_ _1056_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1880_ alu.ALUResult\[18\] seven_seg_conv.temp\[18\] _1751_ VGND VGND VPWR VPWR _0379_
+ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2501_ _0820_ _0831_ _0698_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__mux2_1
X_3550_ _0257_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[24\] sky130_fd_sc_hd__dlxtn_2
X_3481_ reg_file.memory\[25\]\[17\] alu.ALUResult\[17\] _1724_ VGND VGND VPWR VPWR
+ _1732_ sky130_fd_sc_hd__mux2_1
X_2363_ _0661_ _0847_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2294_ _0582_ _0769_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__and2_1
X_2432_ _0661_ _0743_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3748_ clknet_4_8_0_clk _0195_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3679_ clknet_4_10_0_clk _0126_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2981_ _0748_ _1407_ _1437_ _0765_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__o211a_1
X_1863_ _0361_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__inv_2
X_1932_ _0419_ _0424_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__nand2_1
X_3602_ clk_div.slow_clk _0049_ VGND VGND VPWR VPWR seven_seg_conv.temp\[8\] sky130_fd_sc_hd__dfxtp_1
X_2415_ _0894_ _0898_ _0719_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__mux2_1
X_1794_ alu.ALUResult\[31\] alu.ALUResult\[29\] VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__or2b_1
X_3533_ _0270_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[7\] sky130_fd_sc_hd__dlxtn_1
X_3464_ reg_file.memory\[25\]\[9\] alu.ALUResult\[9\] _1713_ VGND VGND VPWR VPWR _1723_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2346_ _0826_ _0830_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2277_ _0749_ _0761_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__and2_2
X_3395_ _1686_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2200_ _0685_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__clkbuf_4
X_2131_ reg_file.memory\[5\]\[11\] reg_file.memory\[15\]\[11\] _0594_ VGND VGND VPWR
+ VPWR _0617_ sky130_fd_sc_hd__mux2_1
X_2062_ _0010_ _0009_ _0011_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__a21bo_1
X_3180_ reg_file.memory\[5\]\[1\] alu.ALUResult\[1\] _1573_ VGND VGND VPWR VPWR _1575_
+ sky130_fd_sc_hd__mux2_1
X_2964_ _1394_ _1421_ _0746_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__mux2_1
X_1777_ seven_seg_conv.digit_counter\[3\] seven_seg_conv.digit_counter\[2\] VGND VGND
+ VPWR VPWR _0276_ sky130_fd_sc_hd__or2_1
XFILLER_0_71_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1846_ _0289_ _0334_ _0336_ _0339_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__a31o_1
X_2895_ _0824_ _1356_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1915_ _0275_ _0410_ _0412_ _0413_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__a2bb2o_1
X_3516_ _0016_ seven_seg_conv.digit_counter\[1\] _1749_ net8 _1489_ VGND VGND VPWR
+ VPWR _0232_ sky130_fd_sc_hd__o32a_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3378_ reg_file.memory\[15\]\[0\] alu.ALUResult\[0\] _1677_ VGND VGND VPWR VPWR _1678_
+ sky130_fd_sc_hd__mux2_1
X_3447_ _1714_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2329_ _0714_ _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__nand2_1
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_62_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2680_ _0620_ _1154_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__xnor2_1
X_3301_ _1636_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__clkbuf_1
X_3232_ reg_file.memory\[5\]\[26\] alu.ALUResult\[26\] _1595_ VGND VGND VPWR VPWR
+ _1602_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3163_ _0333_ _0336_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__nand2_1
X_2114_ _0597_ _0599_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__nand2_1
X_2045_ _0543_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__buf_4
X_3094_ _1497_ _1524_ _1525_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__and3_1
XFILLER_0_71_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2947_ _1403_ _1404_ _1134_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_17_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1829_ _0323_ _0324_ _0327_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__a21o_1
X_2878_ _0625_ _1340_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3781_ clknet_4_11_0_clk _0228_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_2801_ _0852_ _1267_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2732_ _0691_ _1202_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__nor2_1
X_2663_ _1132_ _1126_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__or2b_1
X_2594_ _0770_ _0774_ _0862_ _0866_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__and4_1
XFILLER_0_66_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3215_ reg_file.memory\[5\]\[18\] alu.ALUResult\[18\] _1584_ VGND VGND VPWR VPWR
+ _1593_ sky130_fd_sc_hd__mux2_1
X_3146_ _1556_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
X_2028_ _0522_ _0526_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3077_ _1497_ _1512_ _1514_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__and3_1
XFILLER_0_17_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3000_ _1118_ _1061_ _1211_ _1375_ _1455_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_59_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3764_ clknet_4_12_0_clk _0211_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2715_ _1174_ _1178_ _1179_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__o21a_1
X_2646_ _0867_ _1122_ _0862_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__mux2_1
X_3695_ clknet_4_5_0_clk _0142_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_2577_ _0743_ _1056_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3129_ _0460_ _0469_ _1545_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_25_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_29_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_38_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2500_ _0728_ _0980_ _0982_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_51_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_47_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3480_ _1731_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__clkbuf_1
X_2431_ _0913_ _0914_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__and2_1
X_2362_ reg_file.memory\[25\]\[18\] _0664_ _0846_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__o21a_1
X_2293_ _0579_ _0727_ _0768_ _0777_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__a211o_1
XFILLER_0_63_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_56_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_65_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3747_ clknet_4_9_0_clk _0194_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3678_ clknet_4_10_0_clk _0125_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_2629_ _1013_ _1002_ _0974_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_74_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2980_ _0906_ _1436_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_1_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1793_ alu.ALUResult\[27\] seven_seg_conv.temp\[27\] _1750_ VGND VGND VPWR VPWR _0292_
+ sky130_fd_sc_hd__mux2_1
X_1862_ _0352_ _0359_ _0360_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__a21oi_2
X_1931_ _1760_ _0425_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3601_ clk_div.slow_clk _0048_ VGND VGND VPWR VPWR seven_seg_conv.temp\[7\] sky130_fd_sc_hd__dfxtp_1
X_2414_ _0897_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__inv_2
XFILLER_0_58_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3532_ _0269_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[6\] sky130_fd_sc_hd__dlxtn_1
X_3394_ reg_file.memory\[15\]\[8\] alu.ALUResult\[8\] _1677_ VGND VGND VPWR VPWR _1686_
+ sky130_fd_sc_hd__mux2_1
X_3463_ _1722_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__clkbuf_1
X_2345_ _0678_ _0829_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2276_ reg_file.memory\[25\]\[0\] _0662_ _0760_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__o21a_1
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2130_ _0585_ _0615_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2061_ _0011_ _0545_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__or2b_1
X_2963_ _0878_ _0880_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1914_ _0281_ _0409_ _0411_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3515_ _1489_ net9 _1486_ _1749_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__o22a_1
XFILLER_0_69_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1845_ alu.ALUResult\[22\] seven_seg_conv.temp\[22\] _1751_ VGND VGND VPWR VPWR _0344_
+ sky130_fd_sc_hd__mux2_2
XFILLER_0_60_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2894_ _0629_ _1355_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__xnor2_1
X_1776_ alu.ALUResult\[14\] seven_seg_conv.temp\[14\] _1752_ VGND VGND VPWR VPWR _0275_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2328_ reg_file.memory\[25\]\[25\] _0782_ _0812_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__o21a_1
XFILLER_0_69_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3446_ reg_file.memory\[25\]\[0\] alu.ALUResult\[0\] _1713_ VGND VGND VPWR VPWR _1714_
+ sky130_fd_sc_hd__mux2_1
X_3377_ _1676_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__clkbuf_4
X_2259_ _0591_ _0659_ _0743_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__and3_1
XFILLER_0_50_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3300_ reg_file.memory\[0\]\[28\] VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__clkbuf_1
X_3162_ _1564_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__clkbuf_1
X_3231_ _1601_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2113_ _0583_ _0598_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__nand2_1
X_2044_ seven_seg_conv.digit_counter\[3\] VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__inv_2
X_3093_ clk_div.counter\[13\] _1521_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__nand2_1
X_2946_ _1403_ _1404_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__and2_1
X_2877_ _0627_ _1326_ _1325_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1828_ _0325_ _0326_ _0318_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_9_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3429_ _1704_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3780_ clknet_4_10_0_clk _0227_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_2800_ _0852_ _1267_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__nand2_1
XFILLER_0_41_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2731_ _0691_ _1202_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_14_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2662_ _1096_ _0955_ _1137_ _0780_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__a211o_1
XFILLER_0_14_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2593_ _0968_ _1060_ _1072_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__o21ai_1
X_3214_ _1592_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__clkbuf_1
X_3145_ seven_seg_conv.temp\[14\] _0409_ _0544_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_49_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2027_ _1758_ _0525_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__nor2_1
X_3076_ _1513_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__inv_2
X_2929_ _1387_ _1388_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__and2b_1
XFILLER_0_32_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3763_ clknet_4_7_0_clk _0210_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_2714_ _1185_ _1186_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3694_ clknet_4_4_0_clk _0141_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2645_ _1121_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__inv_2
XFILLER_0_14_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2576_ _0774_ _1055_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__xnor2_1
X_3128_ _1543_ _1544_ _1546_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__o21ai_1
X_3059_ _1501_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_25_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_56_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2361_ reg_file.memory\[0\]\[18\] _0666_ _0669_ reg_file.memory\[10\]\[18\] _0672_
+ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__a221o_1
X_2430_ _0749_ _0735_ _0593_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__a21o_1
X_2292_ _0776_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3677_ clknet_4_8_0_clk _0124_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_3746_ clknet_4_9_0_clk _0193_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_2559_ _0578_ _1039_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__or2_1
X_2628_ _1022_ _1105_ _0860_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__mux2_1
XFILLER_0_65_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1930_ _1760_ _0425_ _0427_ _0428_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__o211ai_2
X_1792_ _0290_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__clkinvlp_2
X_1861_ _0358_ _0355_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__and2_1
X_3531_ _0268_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[5\] sky130_fd_sc_hd__dlxtn_1
X_3600_ clk_div.slow_clk _0047_ VGND VGND VPWR VPWR seven_seg_conv.temp\[6\] sky130_fd_sc_hd__dfxtp_1
X_2413_ _0895_ _0896_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__nand2_1
X_2344_ _0660_ _0828_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__nand2_1
X_3393_ _1685_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
X_3462_ reg_file.memory\[25\]\[8\] alu.ALUResult\[8\] _1713_ VGND VGND VPWR VPWR _1722_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2275_ reg_file.memory\[0\]\[0\] _0575_ _0667_ reg_file.memory\[10\]\[0\] _0670_
+ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__a221o_1
XFILLER_0_59_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3729_ clknet_4_7_0_clk _0176_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2060_ _0012_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__inv_2
X_2962_ _1414_ _1419_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__xnor2_1
X_2893_ _1214_ _1354_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1913_ _0411_ _0281_ _0408_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__nand3_1
X_3514_ _1489_ seven_seg_conv.digit_counter\[2\] VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__nand2_1
X_1844_ _0288_ _0342_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__xnor2_2
X_1775_ _0273_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__inv_2
XFILLER_0_8_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3445_ _1712_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__clkbuf_4
X_2327_ reg_file.memory\[0\]\[25\] _0783_ _0784_ reg_file.memory\[10\]\[25\] _0785_
+ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__a221o_1
XFILLER_0_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2258_ reg_file.memory\[25\]\[5\] _0663_ _0742_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__o21a_1
X_3376_ PC\[2\] PC\[1\] ctrl_unit.RegWrite PC\[0\] VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__and4bb_4
XFILLER_0_79_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2189_ _0661_ _0674_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_3_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3161_ seven_seg_conv.temp\[22\] _0342_ _0544_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__mux2_1
X_3230_ reg_file.memory\[5\]\[25\] alu.ALUResult\[25\] _1595_ VGND VGND VPWR VPWR
+ _1601_ sky130_fd_sc_hd__mux2_1
X_2112_ reg_file.memory\[5\]\[13\] reg_file.memory\[15\]\[13\] _0594_ VGND VGND VPWR
+ VPWR _0598_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2043_ _1755_ _0541_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__xnor2_1
X_3092_ clk_div.counter\[13\] _1521_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_17_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1827_ _0312_ _0314_ _0320_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__a21oi_1
X_2945_ _1384_ _1387_ _1388_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__o21a_1
X_2876_ _0968_ _1333_ _1339_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_44_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3428_ reg_file.memory\[15\]\[24\] alu.ALUResult\[24\] _1699_ VGND VGND VPWR VPWR
+ _1704_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3359_ _1667_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_67_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2661_ _1096_ _0909_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__nor2_1
X_2730_ _0599_ _1201_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_14_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2592_ _0781_ _1064_ _1067_ _0872_ _1071_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__o221a_1
X_3213_ reg_file.memory\[5\]\[17\] alu.ALUResult\[17\] _1584_ VGND VGND VPWR VPWR
+ _1592_ sky130_fd_sc_hd__mux2_1
X_3144_ _1555_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
X_3075_ clk_div.counter\[6\] clk_div.counter\[7\] _1509_ VGND VGND VPWR VPWR _1513_
+ sky130_fd_sc_hd__and3_1
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2026_ _0515_ _0517_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__or2_1
XFILLER_0_72_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2928_ _0813_ _1386_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__or2_1
X_2859_ _0929_ _1041_ _1315_ _1134_ _1323_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_20_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_59_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2713_ _0688_ _1184_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__or2_1
X_3693_ clknet_4_5_0_clk _0140_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_3762_ clknet_4_6_0_clk _0209_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_2644_ _1035_ _1120_ _0725_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__mux2_1
X_2575_ _0770_ _0862_ _0866_ _0993_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__a31o_1
X_3058_ clk_div.counter\[0\] clk_div.counter\[1\] clk_div.counter\[2\] VGND VGND VPWR
+ VPWR _1501_ sky130_fd_sc_hd__and3_1
X_3127_ _1545_ seven_seg_conv.temp\[6\] VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_25_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2009_ _0507_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_56_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
X_2360_ _0593_ _0844_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__nand2_1
X_2291_ _0771_ _0775_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__nand2_2
XFILLER_0_2_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3745_ clknet_4_9_0_clk _0192_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_3676_ clknet_4_14_0_clk _0123_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2627_ _1065_ _1104_ _0719_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__mux2_1
X_2558_ _0821_ _0841_ _0725_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__mux2_1
X_2489_ _0858_ _0684_ _0699_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1860_ _0352_ _0355_ _0358_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_44_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1791_ alu.ALUResult\[25\] seven_seg_conv.temp\[25\] _1751_ VGND VGND VPWR VPWR _0290_
+ sky130_fd_sc_hd__mux2_1
X_3530_ _0267_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[4\] sky130_fd_sc_hd__dlxtn_1
X_3461_ _1721_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__clkbuf_1
X_2412_ _0678_ _0834_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__nand2_1
X_2343_ reg_file.memory\[25\]\[22\] _0782_ _0827_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__o21a_1
X_2274_ _0592_ _0660_ _0758_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__and3_1
X_3392_ reg_file.memory\[15\]\[7\] alu.ALUResult\[7\] _1677_ VGND VGND VPWR VPWR _1685_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_75_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_67_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1989_ _0474_ _0479_ _0481_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__and3_1
XFILLER_0_30_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3659_ clknet_4_5_0_clk _0106_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3728_ clknet_4_6_0_clk _0175_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1843_ _0333_ _0337_ _0338_ _0340_ _0341_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__a32o_2
X_2961_ _1417_ _1418_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__or2_1
XFILLER_0_56_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2892_ _0625_ _0627_ _1326_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__nand3_1
X_1912_ _0402_ _0403_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__nor2_1
X_3513_ _1545_ _1487_ _1748_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__o21ai_1
X_1774_ alu.ALUResult\[13\] seven_seg_conv.temp\[13\] _1752_ VGND VGND VPWR VPWR _0273_
+ sky130_fd_sc_hd__mux2_1
X_3444_ _0013_ ctrl_unit.RegWrite _0580_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__and3_2
X_2326_ _0806_ _0810_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__nand2_1
X_3375_ _1675_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2257_ reg_file.memory\[0\]\[5\] _0665_ _0668_ reg_file.memory\[10\]\[5\] _0671_
+ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__a221o_1
XFILLER_0_18_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2188_ reg_file.memory\[25\]\[15\] _0664_ _0673_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__o21a_1
XFILLER_0_62_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_3_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3160_ _1543_ seven_seg_conv.temp\[21\] _1563_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_55_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2111_ _0583_ _0596_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__nand2_1
X_2042_ _0535_ _0538_ _0540_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__a21o_1
X_3091_ _1523_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1826_ _0316_ _0317_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__nand2_1
X_2944_ _0808_ _1402_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__xor2_1
X_2875_ _0777_ _1064_ _1067_ _1258_ _1338_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__o221a_1
XFILLER_0_44_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3358_ alu.ALUResult\[23\] reg_file.memory\[10\]\[23\] _1663_ VGND VGND VPWR VPWR
+ _1667_ sky130_fd_sc_hd__mux2_1
X_3427_ _1703_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2309_ _0679_ _0788_ _0793_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__o21ai_1
X_3289_ _1630_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2660_ _1116_ _0891_ _0777_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_14_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2591_ _0977_ _1068_ _1070_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__o21a_1
X_3212_ _1591_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_66_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3143_ seven_seg_conv.temp\[13\] _0422_ _1534_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__mux2_1
X_2025_ _1758_ _0523_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__xnor2_1
X_3074_ clk_div.counter\[5\] clk_div.counter\[6\] _1505_ clk_div.counter\[7\] VGND
+ VGND VPWR VPWR _1512_ sky130_fd_sc_hd__a31o_1
X_2927_ _0813_ _1386_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_37_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1809_ alu.ALUResult\[30\] _0279_ _0296_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__and3_1
X_2858_ _1321_ _1322_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__nor2_1
X_2789_ _0771_ _1257_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__or2_2
XPHY_EDGE_ROW_17_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3761_ clknet_4_6_0_clk _0208_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_2712_ _0688_ _1184_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__nand2_1
X_3692_ clknet_4_4_0_clk _0139_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2574_ _0739_ _1048_ _1050_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_22_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2643_ _1084_ _1119_ _0697_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3126_ seven_seg_conv.digit_counter\[3\] VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_25_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3057_ _1500_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
X_2008_ alu.ALUResult\[4\] seven_seg_conv.temp\[4\] _1753_ VGND VGND VPWR VPWR _0507_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_56_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2290_ alu.ALUControl\[0\] _0772_ _0774_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__and3_2
XFILLER_0_63_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3744_ clknet_4_9_0_clk _0191_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_25_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2557_ _0728_ _0803_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__or2_2
X_3675_ clknet_4_8_0_clk _0122_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2626_ _0914_ _0917_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2488_ _0969_ _0970_ _0729_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_43_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3109_ _0530_ _0532_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_52_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_61_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1790_ alu.ALUResult\[24\] seven_seg_conv.temp\[24\] _1751_ VGND VGND VPWR VPWR _0289_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2411_ _0592_ _0829_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_70_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3391_ _1684_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__clkbuf_1
X_3460_ reg_file.memory\[25\]\[7\] alu.ALUResult\[7\] _1713_ VGND VGND VPWR VPWR _1721_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_67_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2342_ reg_file.memory\[0\]\[22\] _0783_ _0784_ reg_file.memory\[10\]\[22\] _0785_
+ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__a221o_1
X_2273_ reg_file.memory\[25\]\[1\] _0662_ _0757_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_75_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1988_ alu.ALUResult\[6\] seven_seg_conv.temp\[6\] _1753_ VGND VGND VPWR VPWR _0487_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3727_ clknet_4_7_0_clk _0174_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_23_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2609_ _0860_ _0981_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__and2_1
X_3658_ clknet_4_0_0_clk _0105_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_3589_ clknet_4_3_0_clk _0036_ VGND VGND VPWR VPWR clk_div.counter\[15\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_65_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_5_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2960_ _0805_ _1416_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_64_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1842_ _0289_ _0334_ _0336_ _0339_ _0287_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__a311o_1
XFILLER_0_69_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2891_ _0828_ _1341_ _1352_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_44_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1911_ _0281_ _0409_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__xnor2_1
X_1773_ alu.ALUResult\[12\] seven_seg_conv.temp\[12\] _1752_ VGND VGND VPWR VPWR _1760_
+ sky130_fd_sc_hd__mux2_2
X_3512_ _1545_ net10 VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__nand2_1
X_3443_ _1711_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__clkbuf_1
X_3374_ alu.ALUResult\[31\] reg_file.memory\[10\]\[31\] _1640_ VGND VGND VPWR VPWR
+ _1675_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2325_ _0678_ _0809_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__nand2_1
X_2187_ reg_file.memory\[0\]\[15\] _0666_ _0669_ reg_file.memory\[10\]\[15\] _0672_
+ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__a221o_1
X_2256_ _0592_ _0740_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_3_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2110_ reg_file.memory\[5\]\[12\] reg_file.memory\[15\]\[12\] _0595_ VGND VGND VPWR
+ VPWR _0596_ sky130_fd_sc_hd__mux2_1
X_2041_ _0530_ _0539_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__and2_1
X_3090_ _1497_ _1520_ _1522_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__and3_1
XFILLER_0_71_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2943_ _0607_ _1401_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__xnor2_1
X_1825_ _0312_ _0321_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__xnor2_1
X_2874_ _1210_ _1256_ _1337_ _0872_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__o22a_1
XFILLER_0_44_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2308_ _0789_ _0792_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__nand2_1
X_3357_ _1666_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__clkbuf_1
X_3426_ reg_file.memory\[15\]\[23\] alu.ALUResult\[23\] _1699_ VGND VGND VPWR VPWR
+ _1703_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3288_ reg_file.memory\[0\]\[22\] VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2239_ _0582_ _0722_ _0723_ _0581_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__a31o_1
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2590_ _0766_ _0954_ _1069_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_26_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3211_ reg_file.memory\[5\]\[16\] alu.ALUResult\[16\] _1584_ VGND VGND VPWR VPWR
+ _1591_ sky130_fd_sc_hd__mux2_1
X_3142_ _1554_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
X_2024_ _0516_ _0518_ _0522_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__a21o_1
X_3073_ clk_div.counter\[6\] _1509_ _1511_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__o21a_1
XFILLER_0_72_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2926_ _0614_ _1385_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__xnor2_1
X_2857_ _1257_ _1036_ _1083_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__o21a_1
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1808_ _0304_ _0305_ _0306_ _0295_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__a22o_1
X_2788_ _0578_ _0869_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__or2_1
X_3409_ reg_file.memory\[15\]\[15\] alu.ALUResult\[15\] _1688_ VGND VGND VPWR VPWR
+ _1694_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2711_ _0597_ _1183_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__xor2_1
X_3760_ clknet_4_6_0_clk _0207_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3691_ clknet_4_5_0_clk _0138_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_2573_ _1053_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__clkbuf_1
X_2642_ _0736_ _0713_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3125_ _0479_ _0481_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3056_ _1492_ _1499_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__and2_1
X_2007_ _0501_ _0505_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__nand2_1
X_2909_ _0819_ _0826_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3743_ clknet_4_15_0_clk _0190_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_3674_ clknet_4_14_0_clk _0121_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2556_ _0780_ _0775_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__and2_1
X_2625_ _1076_ _1081_ _1101_ _0873_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__a31o_1
X_2487_ _0737_ _0718_ _0921_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3108_ _1532_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3039_ seven_seg_conv.digit_counter\[2\] seven_seg_conv.digit_counter\[0\] seven_seg_conv.digit_counter\[1\]
+ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_53_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2341_ _0592_ _0825_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__nand2_1
X_2410_ _0892_ _0893_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__and2_1
XFILLER_0_58_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3390_ reg_file.memory\[15\]\[6\] alu.ALUResult\[6\] _1677_ VGND VGND VPWR VPWR _1684_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2272_ reg_file.memory\[0\]\[1\] _0575_ _0667_ reg_file.memory\[10\]\[1\] _0670_
+ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_75_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3657_ clknet_4_3_0_clk _0104_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3726_ clknet_4_6_0_clk _0173_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_1987_ _0474_ _0473_ _0481_ _0485_ _0479_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__o311a_1
XFILLER_0_23_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2608_ _0974_ _1085_ _1086_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__a21oi_2
X_2539_ _0922_ _0924_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3588_ clknet_4_2_0_clk _0035_ VGND VGND VPWR VPWR clk_div.counter\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2890_ _1342_ _1343_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__or2b_1
X_1910_ _0404_ _0405_ _0408_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__a21o_1
X_1841_ _0329_ _0339_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__xor2_1
X_3511_ _1747_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1772_ alu.ALUResult\[10\] seven_seg_conv.temp\[10\] _1752_ VGND VGND VPWR VPWR _1759_
+ sky130_fd_sc_hd__mux2_1
X_2324_ _0714_ _0808_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__nand2_1
X_3373_ _1674_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
X_3442_ reg_file.memory\[15\]\[31\] alu.ALUResult\[31\] _1676_ VGND VGND VPWR VPWR
+ _1711_ sky130_fd_sc_hd__mux2_1
X_2186_ _0671_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__buf_2
X_2255_ _0660_ _0739_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3709_ clknet_4_11_0_clk _0156_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_3_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2040_ _0536_ _0532_ _0529_ _0527_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2942_ _1325_ _1400_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_60_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2873_ _1273_ _1336_ _0974_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1824_ _0321_ _0322_ _0290_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__or3_1
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_20_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2307_ _0714_ _0791_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__nand2_1
X_3356_ alu.ALUResult\[22\] reg_file.memory\[10\]\[22\] _1663_ VGND VGND VPWR VPWR
+ _1666_ sky130_fd_sc_hd__mux2_1
X_3287_ _1629_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__clkbuf_1
X_3425_ _1702_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2238_ reg_file.memory\[15\]\[2\] _0587_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2169_ reg_file.memory\[5\]\[17\] reg_file.memory\[15\]\[17\] _0595_ VGND VGND VPWR
+ VPWR _0655_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3210_ _1590_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__clkbuf_1
X_3141_ seven_seg_conv.temp\[12\] _0424_ _1534_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2023_ _0511_ _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__and2_1
X_3072_ clk_div.counter\[6\] _1509_ _1497_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_15_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1807_ _0297_ _0299_ _0300_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__a21o_1
X_2925_ _0616_ _1377_ _1325_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__a21o_1
X_2856_ _1096_ _1194_ _1320_ _0771_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__o211a_1
XFILLER_0_79_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2787_ _0578_ _0870_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__nand2_2
X_3408_ _1693_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3339_ alu.ALUResult\[14\] reg_file.memory\[10\]\[14\] _1652_ VGND VGND VPWR VPWR
+ _1657_ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2710_ _1175_ _1182_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__nor2_1
X_3690_ clknet_4_0_0_clk _0137_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2641_ _0930_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__clkbuf_4
X_2572_ _1042_ _1046_ _1052_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__or3_1
XFILLER_0_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3055_ clk_div.counter\[0\] clk_div.counter\[1\] VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__nand2_1
X_3124_ seven_seg_conv.digit_counter\[3\] VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_45_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2006_ _0502_ _0503_ _0504_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__or3_1
XFILLER_0_60_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2839_ _0976_ _1304_ VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__nor2_1
X_2908_ _1369_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3742_ clknet_4_9_0_clk _0189_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_3673_ clknet_4_12_0_clk _0120_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2624_ _1076_ _1081_ _1101_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__a21oi_1
X_2486_ _0745_ _0756_ _0748_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__mux2_1
X_2555_ _0679_ _0762_ _1017_ _1035_ _0974_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__a32oi_4
X_3038_ _1485_ _1486_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__nand2_1
X_3107_ seven_seg_conv.temp\[0\] _0541_ _1489_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_53_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2340_ _0714_ _0824_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__nand2_1
X_2271_ _0679_ _0749_ _0751_ _0755_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__a31o_1
XFILLER_0_74_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1986_ _0478_ _0477_ _0481_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_23_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2607_ _0765_ _0989_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__nor2_1
X_3656_ clknet_4_2_0_clk _0103_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3587_ clknet_4_2_0_clk _0034_ VGND VGND VPWR VPWR clk_div.counter\[13\] sky130_fd_sc_hd__dfxtp_1
X_3725_ clknet_4_5_0_clk _0172_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2538_ _0976_ _1015_ _1019_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__o21ai_1
X_2469_ _0906_ _0952_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__or2_1
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_72_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1840_ _0333_ _0336_ _0289_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_60_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3441_ _1710_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3510_ reg_file.memory\[25\]\[31\] alu.ALUResult\[31\] _1712_ VGND VGND VPWR VPWR
+ _1747_ sky130_fd_sc_hd__mux2_1
X_1771_ alu.ALUResult\[3\] seven_seg_conv.temp\[3\] _1753_ VGND VGND VPWR VPWR _1758_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2323_ reg_file.memory\[25\]\[26\] _0782_ _0807_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__o21a_1
X_3372_ alu.ALUResult\[30\] reg_file.memory\[10\]\[30\] _1640_ VGND VGND VPWR VPWR
+ _1674_ sky130_fd_sc_hd__mux2_1
X_2254_ reg_file.memory\[25\]\[4\] _0663_ _0738_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__o21a_1
XFILLER_0_79_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2185_ _0670_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__buf_2
XFILLER_0_62_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1969_ _0467_ _0461_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__nand2_1
X_3708_ clknet_4_8_0_clk _0155_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_3639_ clknet_4_13_0_clk _0086_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1823_ _0313_ _0318_ _0320_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__and3_1
X_2872_ _1335_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__inv_2
X_2941_ _0614_ _0616_ _1377_ VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__and3_1
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3424_ reg_file.memory\[15\]\[22\] alu.ALUResult\[22\] _1699_ VGND VGND VPWR VPWR
+ _1702_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2306_ reg_file.memory\[25\]\[30\] _0782_ _0790_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__o21a_1
X_3355_ _1665_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__clkbuf_1
X_3286_ reg_file.memory\[0\]\[21\] VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__clkbuf_1
X_2237_ reg_file.memory\[5\]\[2\] _0589_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2099_ _0584_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__buf_4
X_2168_ _0584_ _0653_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3140_ _1543_ seven_seg_conv.temp\[11\] _1553_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__a21bo_1
X_3071_ _1509_ _1510_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2022_ _0519_ _0514_ _0520_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_15_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1806_ _0299_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__inv_2
X_2924_ _0817_ _1379_ _1383_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__a21bo_1
X_2855_ _0910_ _1319_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__nand2_1
X_2786_ _1236_ _1239_ _1253_ _0873_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__a31o_1
XFILLER_0_31_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3407_ reg_file.memory\[15\]\[14\] alu.ALUResult\[14\] _1688_ VGND VGND VPWR VPWR
+ _1693_ sky130_fd_sc_hd__mux2_1
X_3338_ _1656_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__clkbuf_1
X_3269_ _1620_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2640_ _0771_ _1116_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__or2_2
X_2571_ _1050_ _1051_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3054_ _1498_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
X_3123_ _1542_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
X_2005_ _0498_ _0499_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__nand2_1
X_2907_ _1362_ _1366_ _1367_ _1368_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__or4b_1
XFILLER_0_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2838_ _1244_ _1303_ _0765_ VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__mux2_1
X_2769_ _1218_ _1222_ _1238_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_56_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3741_ clknet_4_14_0_clk _0188_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_3672_ clknet_4_12_0_clk _0119_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2623_ _0735_ _1100_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__xnor2_1
X_2554_ _0698_ _0988_ _1034_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__o21ai_2
X_2485_ _0912_ _0932_ _0958_ _0967_ _0968_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__o32a_1
X_3037_ _0016_ seven_seg_conv.digit_counter\[1\] VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3106_ clk_div.counter\[19\] _1531_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_53_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_21_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_30_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2270_ _0677_ _0754_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3724_ clknet_4_1_0_clk _0171_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_1985_ _0483_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__clkinvlp_2
XFILLER_0_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2537_ _0863_ _1018_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__or2_1
XFILLER_0_30_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2606_ _1033_ _1084_ _0888_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__mux2_1
X_3655_ clknet_4_0_0_clk _0102_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3586_ clknet_4_2_0_clk _0033_ VGND VGND VPWR VPWR clk_div.counter\[12\] sky130_fd_sc_hd__dfxtp_1
X_2399_ _0879_ _0882_ _0719_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2468_ _0686_ _0950_ _0951_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_3_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_72_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1770_ _1756_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__inv_2
X_3371_ _1673_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_69_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3440_ reg_file.memory\[15\]\[30\] alu.ALUResult\[30\] _1676_ VGND VGND VPWR VPWR
+ _1710_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2322_ reg_file.memory\[0\]\[26\] _0783_ _0784_ reg_file.memory\[10\]\[26\] _0785_
+ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__a221o_1
X_2184_ _0576_ _0239_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__nand2_1
X_2253_ reg_file.memory\[0\]\[4\] _0665_ _0668_ reg_file.memory\[10\]\[4\] _0671_
+ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__a221o_1
XFILLER_0_18_51 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3707_ clknet_4_8_0_clk _0154_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1899_ _0396_ _0397_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__or2_1
XFILLER_0_35_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1968_ _0452_ _0465_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3638_ clknet_4_13_0_clk _0085_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_3569_ clk_div.slow_clk _0012_ VGND VGND VPWR VPWR seven_seg_conv.current_digit\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_53_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_9_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2940_ _1399_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__clkbuf_1
X_1822_ _0318_ _0320_ _0313_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__a21oi_1
X_2871_ _1301_ _1334_ _0888_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3354_ alu.ALUResult\[21\] reg_file.memory\[10\]\[21\] _1663_ VGND VGND VPWR VPWR
+ _1665_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3423_ _1701_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2305_ reg_file.memory\[0\]\[30\] _0783_ _0784_ reg_file.memory\[10\]\[30\] _0785_
+ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__a221o_1
X_3285_ _1628_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__clkbuf_1
X_2167_ reg_file.memory\[5\]\[16\] reg_file.memory\[15\]\[16\] _0595_ VGND VGND VPWR
+ VPWR _0653_ sky130_fd_sc_hd__mux2_1
X_2236_ _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__inv_2
XFILLER_0_75_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2098_ _0583_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__buf_2
XFILLER_0_0_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3070_ clk_div.counter\[5\] _1505_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__nor2_1
X_2021_ _0509_ _0510_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__or2_1
X_2923_ _1380_ _1381_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_59_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1805_ _0295_ _0300_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_68_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2854_ _1316_ _1318_ _0765_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__mux2_1
X_2785_ _1236_ _1239_ _1253_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_32_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3406_ _1692_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__clkbuf_1
X_3337_ alu.ALUResult\[13\] reg_file.memory\[10\]\[13\] _1652_ VGND VGND VPWR VPWR
+ _1656_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_77_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2219_ _0592_ _0703_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__nor2_1
X_3199_ reg_file.memory\[5\]\[10\] alu.ALUResult\[10\] _1584_ VGND VGND VPWR VPWR
+ _1585_ sky130_fd_sc_hd__mux2_1
X_3268_ reg_file.memory\[0\]\[12\] VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_11_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2570_ _1027_ _1030_ _1049_ _0772_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__a31o_1
XFILLER_0_22_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3122_ seven_seg_conv.temp\[5\] _1541_ _1534_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__mux2_1
X_3053_ clk_div.counter\[0\] _1497_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__and2b_1
X_2004_ seven_seg_conv.temp\[5\] _0279_ _0495_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__o21ai_1
X_2906_ _0976_ _1111_ _1113_ _0776_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__a211o_1
XFILLER_0_42_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2837_ _0906_ _1301_ _1302_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2768_ _1236_ _1237_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__nand2_1
X_2699_ _1118_ _1004_ _0957_ _1015_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_13_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3740_ clknet_4_15_0_clk _0187_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3671_ clknet_4_12_0_clk _0118_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2622_ _0647_ _1099_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__xnor2_1
X_2553_ _0698_ _1033_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__nand2_1
X_3105_ _1530_ _1531_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__nor2_1
X_2484_ _0772_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_77_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3036_ seven_seg_conv.digit_counter\[0\] _0277_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__nand2_1
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_18_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3654_ clknet_4_8_0_clk _0101_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_3723_ clknet_4_4_0_clk _0170_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1984_ _0473_ _0482_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__xor2_2
XFILLER_0_15_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2536_ _0725_ _1016_ _1017_ _0884_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__a22o_1
X_2467_ _0677_ _0689_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__or2_1
X_2605_ _0733_ _0744_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__or2_1
X_3585_ clknet_4_2_0_clk _0032_ VGND VGND VPWR VPWR clk_div.counter\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2398_ _0880_ _0881_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_66_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3019_ _1471_ _1472_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2321_ _0661_ _0805_ _0678_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__a21o_1
X_3370_ alu.ALUResult\[29\] reg_file.memory\[10\]\[29\] _1663_ VGND VGND VPWR VPWR
+ _1673_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2183_ _0668_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__buf_2
XFILLER_0_18_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2252_ _0733_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__or2_1
XFILLER_0_47_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3706_ clknet_4_14_0_clk _0153_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1898_ _0284_ _0392_ _0395_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__a21oi_1
X_3637_ clknet_4_13_0_clk _0084_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_1967_ _0452_ _0462_ _0465_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__o21ai_1
X_3499_ _1741_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__clkbuf_1
X_3568_ clk_div.slow_clk _0011_ VGND VGND VPWR VPWR seven_seg_conv.current_digit\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_2519_ _0978_ _0992_ _1001_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__a21oi_1
X_2870_ _0896_ _0900_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__and2_1
XFILLER_0_71_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1821_ _0319_ _0303_ _0307_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3284_ reg_file.memory\[0\]\[20\] VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__clkbuf_1
X_3353_ _1664_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__clkbuf_1
X_3422_ reg_file.memory\[15\]\[21\] alu.ALUResult\[21\] _1699_ VGND VGND VPWR VPWR
+ _1701_ sky130_fd_sc_hd__mux2_1
X_2304_ _0677_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_45_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2166_ _0645_ _0647_ _0649_ _0651_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_0_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2097_ _0582_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__clkbuf_4
X_2235_ _0709_ _0718_ _0719_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__mux2_1
X_2999_ _0579_ _1337_ _1454_ _0934_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__a211o_1
XFILLER_0_28_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_39_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2020_ _0501_ _0505_ _0508_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__and3_1
X_2853_ _0906_ _0839_ _0845_ _1317_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__a31o_1
X_2922_ _1374_ _1376_ _0968_ _1382_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_15_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1804_ _0292_ _0301_ _0302_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__or3_1
X_2784_ _0855_ _1252_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3405_ reg_file.memory\[15\]\[13\] alu.ALUResult\[13\] _1688_ VGND VGND VPWR VPWR
+ _1692_ sky130_fd_sc_hd__mux2_1
X_3336_ _1655_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3267_ _1619_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__clkbuf_1
X_2149_ reg_file.memory\[5\]\[29\] reg_file.memory\[15\]\[29\] _0603_ VGND VGND VPWR
+ VPWR _0635_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3198_ _1572_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__clkbuf_4
X_2218_ _0660_ _0702_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_28_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_12_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3121_ _0493_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__clkinvlp_2
XFILLER_0_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3052_ clk_div.slow_clk _1497_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__xnor2_1
X_2003_ _0484_ _0490_ _0491_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__a21oi_1
X_2836_ _0699_ _1272_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2905_ _1106_ _1258_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2767_ _0674_ _1235_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__or2_1
X_2698_ _1037_ _1096_ _1018_ _0868_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__a31o_1
XFILLER_0_13_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3319_ _1646_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3670_ clknet_4_13_0_clk _0117_ VGND VGND VPWR VPWR reg_file.memory\[0\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2552_ _0741_ _0755_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__or2_1
X_2483_ _0965_ _0966_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__and2_1
X_2621_ _0649_ _1073_ _0993_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_78_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3104_ clk_div.counter\[17\] clk_div.counter\[18\] _1529_ VGND VGND VPWR VPWR _1531_
+ sky130_fd_sc_hd__and3_1
X_3035_ _1484_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2819_ _0849_ _0853_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3653_ clknet_4_8_0_clk _0100_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_2604_ _0934_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__buf_2
X_3722_ clknet_4_1_0_clk _0169_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_1983_ _0479_ _0481_ _0474_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2466_ _0749_ _0706_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__and2_1
X_2535_ _0725_ _0921_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__nor2_2
X_3584_ clknet_4_2_0_clk _0031_ VGND VGND VPWR VPWR clk_div.counter\[10\] sky130_fd_sc_hd__dfxtp_1
X_2397_ _0789_ _0814_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__nand2_1
X_3018_ _0605_ _0787_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_66_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2320_ reg_file.memory\[25\]\[27\] _0782_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_0_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2251_ _0591_ _0659_ _0735_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_63_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
X_2182_ _0667_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__buf_2
XFILLER_0_18_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1966_ _1759_ _0443_ _0446_ _0450_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__a31o_1
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3705_ clknet_4_14_0_clk _0152_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_1897_ _0392_ _0386_ _0395_ _0284_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__o211a_1
X_3636_ clknet_4_7_0_clk _0083_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_3567_ clk_div.slow_clk _0010_ VGND VGND VPWR VPWR seven_seg_conv.current_digit\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3498_ reg_file.memory\[25\]\[25\] alu.ALUResult\[25\] _1735_ VGND VGND VPWR VPWR
+ _1741_ sky130_fd_sc_hd__mux2_1
X_2449_ _0780_ _0869_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__or2_1
X_2518_ _0999_ _1000_ _0968_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_78_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1820_ _0310_ _0303_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3421_ _1700_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2303_ _0661_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__and2_1
X_3352_ alu.ALUResult\[20\] reg_file.memory\[10\]\[20\] _1663_ VGND VGND VPWR VPWR
+ _1664_ sky130_fd_sc_hd__mux2_1
X_3283_ _1627_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__clkbuf_1
X_2234_ _0697_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__buf_4
X_2165_ _0584_ _0650_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__nand2_2
X_2096_ _0574_ PC\[0\] _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__a21oi_4
X_2998_ _0766_ _1452_ _1453_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_61_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1949_ _0440_ _0447_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__xnor2_1
X_3619_ clk_div.slow_clk _0066_ VGND VGND VPWR VPWR seven_seg_conv.temp\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1803_ _0300_ _0297_ _0299_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__and3_1
X_2852_ _0746_ _1286_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__nor2_1
X_2921_ _1380_ _1381_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__xnor2_1
X_2783_ _0654_ _1251_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_31_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3404_ _1691_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3335_ alu.ALUResult\[12\] reg_file.memory\[10\]\[12\] _1652_ VGND VGND VPWR VPWR
+ _1655_ sky130_fd_sc_hd__mux2_1
X_3197_ _1583_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__clkbuf_1
X_3266_ reg_file.memory\[0\]\[11\] VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2217_ reg_file.memory\[25\]\[10\] _0663_ _0701_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__o21a_1
XFILLER_0_72_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2148_ _0585_ _0633_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_36_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2079_ _0556_ _0565_ _0569_ _0559_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3120_ _1540_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
X_3051_ _1490_ _1491_ _1492_ _1496_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__or4_4
XFILLER_0_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2002_ _0492_ _0500_ _0496_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__a21o_1
X_2835_ _0901_ _0903_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__and2_1
X_2904_ _1246_ _1256_ _1365_ _0935_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2766_ _0674_ _1235_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__nand2_1
X_2697_ _1083_ _1170_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3318_ alu.ALUResult\[4\] reg_file.memory\[10\]\[4\] _1641_ VGND VGND VPWR VPWR _1646_
+ sky130_fd_sc_hd__mux2_1
X_3249_ _1610_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2620_ _0968_ _1082_ _1093_ _1098_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_50_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2482_ _0875_ _0964_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__nand2_1
X_2551_ _1011_ _1024_ _1032_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_78_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3103_ clk_div.counter\[17\] _1529_ clk_div.counter\[18\] VGND VGND VPWR VPWR _1530_
+ sky130_fd_sc_hd__a21oi_1
X_3034_ _0240_ _1483_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2818_ _1282_ _1284_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__xnor2_1
X_2749_ _1218_ _1219_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1982_ _0460_ _0471_ _0480_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__mux2_1
X_2534_ _0887_ _0879_ _0719_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__mux2_1
X_3652_ clknet_4_8_0_clk _0099_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_3721_ clknet_4_1_0_clk _0168_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3583_ clknet_4_2_0_clk _0030_ VGND VGND VPWR VPWR clk_div.counter\[9\] sky130_fd_sc_hd__dfxtp_1
X_2603_ _1080_ _1081_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__nand2_1
X_2396_ _0685_ _0809_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__nand2_1
X_2465_ _0947_ _0948_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_66_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3017_ _0609_ _1325_ _1458_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_64_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2250_ reg_file.memory\[25\]\[7\] _0663_ _0734_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_63_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2181_ _0575_ _0239_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__nand2_2
XFILLER_0_55_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3704_ clknet_4_12_0_clk _0151_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1965_ alu.ALUResult\[8\] seven_seg_conv.temp\[8\] _1753_ VGND VGND VPWR VPWR _0464_
+ sky130_fd_sc_hd__mux2_2
X_3497_ _1740_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1896_ _0385_ _0387_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__or2_1
X_3635_ clknet_4_13_0_clk _0082_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_3566_ clk_div.slow_clk _0009_ VGND VGND VPWR VPWR seven_seg_conv.current_digit\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2517_ _0962_ _0965_ _0998_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__nand3_1
XFILLER_0_52_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2379_ _0822_ _0861_ _0863_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__mux2_1
X_2448_ _0766_ _0919_ _0927_ _0931_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__o211a_1
XFILLER_0_38_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3351_ _1640_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__clkbuf_4
X_3420_ reg_file.memory\[15\]\[20\] alu.ALUResult\[20\] _1699_ VGND VGND VPWR VPWR
+ _1700_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2302_ reg_file.memory\[25\]\[31\] _0782_ _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__o21a_1
X_3282_ reg_file.memory\[0\]\[19\] VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__clkbuf_1
X_2164_ reg_file.memory\[5\]\[19\] reg_file.memory\[15\]\[19\] _0595_ VGND VGND VPWR
+ VPWR _0650_ sky130_fd_sc_hd__mux2_1
X_2233_ _0713_ _0717_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2095_ PC\[0\] _0580_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__nor2_4
X_2997_ _0728_ _1395_ _0578_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__a21o_1
X_1879_ _0286_ _0377_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_43_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1948_ _0437_ _0444_ _0435_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__a21o_1
X_3618_ clk_div.slow_clk _0065_ VGND VGND VPWR VPWR seven_seg_conv.temp\[24\] sky130_fd_sc_hd__dfxtp_1
X_3549_ _0256_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[23\] sky130_fd_sc_hd__dlxtn_1
XTAP_TAPCELL_ROW_39_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_66_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2920_ _1353_ _1357_ _1358_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_57_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1802_ _0297_ _0299_ _0300_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__a21oi_1
X_2782_ _1175_ _1250_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2851_ _1260_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_28_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_37_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3403_ reg_file.memory\[15\]\[12\] alu.ALUResult\[12\] _1688_ VGND VGND VPWR VPWR
+ _1691_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3334_ _1654_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__clkbuf_1
X_2147_ reg_file.memory\[5\]\[27\] reg_file.memory\[15\]\[27\] _0603_ VGND VGND VPWR
+ VPWR _0633_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3265_ _1618_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__clkbuf_1
X_3196_ reg_file.memory\[5\]\[9\] alu.ALUResult\[9\] _1573_ VGND VGND VPWR VPWR _1583_
+ sky130_fd_sc_hd__mux2_1
X_2216_ reg_file.memory\[0\]\[10\] _0665_ _0668_ reg_file.memory\[10\]\[10\] _0671_
+ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_46_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2078_ _0010_ _0009_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__nand2b_1
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_55_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_64_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_73_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3050_ _1493_ _1494_ _1495_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__or3_1
X_2001_ _0494_ _0496_ _0498_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__a2bb2o_1
X_2903_ _1303_ _1364_ _0726_ VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2834_ _1292_ _1299_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__xnor2_1
X_2765_ _0623_ _1234_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__xnor2_1
X_2696_ _1023_ _1169_ _0910_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3317_ _1645_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3179_ _1574_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__clkbuf_1
X_3248_ reg_file.memory\[0\]\[2\] VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_24_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2550_ _1030_ _1031_ _0873_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__a21oi_1
X_2481_ _0875_ _0964_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_78_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3102_ clk_div.counter\[17\] _1529_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__xor2_1
X_3033_ _0574_ _0586_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2817_ _1265_ _1283_ _1269_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__o21a_1
XFILLER_0_41_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2748_ _0681_ _1217_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__or2_1
X_2679_ _0993_ _1153_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3720_ clknet_4_1_0_clk _0167_ VGND VGND VPWR VPWR reg_file.memory\[15\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_1981_ _0463_ _0464_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__nor2_1
X_3651_ clknet_4_9_0_clk _0098_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_2533_ _1012_ _1014_ _0726_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3582_ clknet_4_2_0_clk _0029_ VGND VGND VPWR VPWR clk_div.counter\[8\] sky130_fd_sc_hd__dfxtp_1
X_2602_ _1078_ _1079_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__or2_1
X_2395_ _0789_ _0797_ _0878_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__o21a_1
XFILLER_0_48_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2464_ _0749_ _0716_ _0593_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_66_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3016_ _1096_ _0929_ _1088_ _1457_ _1470_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__a311o_1
XFILLER_0_3_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_6_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2180_ _0665_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__buf_2
XFILLER_0_18_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1895_ _0284_ _0393_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__xnor2_1
X_3703_ clknet_4_12_0_clk _0150_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_3634_ clknet_4_7_0_clk _0081_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1964_ _0452_ _0462_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__xnor2_1
X_3496_ reg_file.memory\[25\]\[24\] alu.ALUResult\[24\] _1735_ VGND VGND VPWR VPWR
+ _1740_ sky130_fd_sc_hd__mux2_1
X_2447_ _0930_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__inv_2
X_3565_ clknet_4_0_0_clk _0020_ VGND VGND VPWR VPWR clk_div.slow_clk sky130_fd_sc_hd__dfxtp_4
X_2516_ _0962_ _0965_ _0998_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__a21o_1
XFILLER_0_45_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2378_ _0862_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_38_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2301_ reg_file.memory\[0\]\[31\] _0783_ _0784_ reg_file.memory\[10\]\[31\] _0785_
+ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__a221o_1
X_3350_ _1662_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3281_ _1626_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__clkbuf_1
X_2232_ _0592_ _0714_ _0716_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__and3_1
XFILLER_0_29_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2163_ _0583_ _0648_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__nand2_2
XFILLER_0_0_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2094_ _0574_ PC\[1\] VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__and2_1
X_3617_ clk_div.slow_clk _0064_ VGND VGND VPWR VPWR seven_seg_conv.temp\[23\] sky130_fd_sc_hd__dfxtp_1
X_2996_ _1421_ _1451_ _0748_ VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__mux2_1
X_1878_ _0371_ _0374_ _0376_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1947_ _0437_ _0444_ _0445_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__o21ai_2
X_3548_ _0255_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[22\] sky130_fd_sc_hd__dlxtn_1
X_3479_ reg_file.memory\[25\]\[16\] alu.ALUResult\[16\] _1724_ VGND VGND VPWR VPWR
+ _1731_ sky130_fd_sc_hd__mux2_1
XFILLER_0_66_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2850_ _1313_ _1314_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1801_ alu.ALUResult\[28\] seven_seg_conv.temp\[28\] _1750_ VGND VGND VPWR VPWR _0300_
+ sky130_fd_sc_hd__mux2_1
X_2781_ _0623_ _1233_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_13_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3402_ _1690_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__clkbuf_1
X_3333_ alu.ALUResult\[11\] reg_file.memory\[10\]\[11\] _1652_ VGND VGND VPWR VPWR
+ _1654_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3264_ reg_file.memory\[0\]\[10\] VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2146_ _0600_ _0602_ _0612_ _0631_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__and4b_1
X_2215_ _0684_ _0694_ _0699_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__mux2_1
X_2077_ _0568_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
X_3195_ _1582_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__clkbuf_1
X_2979_ _0686_ _0797_ _0806_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_36_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2000_ _0487_ _0497_ _0493_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__or3_1
X_2902_ _1334_ _1363_ _0699_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__mux2_1
X_2833_ _1296_ _1298_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_33_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2764_ _1175_ _1233_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__or2_1
X_2695_ _1105_ _1168_ _0974_ VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3316_ alu.ALUResult\[3\] reg_file.memory\[10\]\[3\] _1641_ VGND VGND VPWR VPWR _1645_
+ sky130_fd_sc_hd__mux2_1
X_3247_ _1609_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__clkbuf_1
X_2129_ reg_file.memory\[5\]\[24\] reg_file.memory\[15\]\[24\] _0603_ VGND VGND VPWR
+ VPWR _0615_ sky130_fd_sc_hd__mux2_1
X_3178_ reg_file.memory\[5\]\[0\] alu.ALUResult\[0\] _1573_ VGND VGND VPWR VPWR _1574_
+ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_16_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2480_ _0962_ _0963_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3101_ _1528_ _1529_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_78_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3032_ _0586_ _1482_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__nor2_1
X_2816_ _1268_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__inv_2
XFILLER_0_33_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2747_ _0681_ _1217_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__nand2_1
X_2678_ _0641_ _0643_ _1127_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__and3_1
XFILLER_0_68_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3650_ clknet_4_9_0_clk _0097_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_1980_ _0475_ _0470_ _0472_ _0477_ _0478_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__a311o_1
XFILLER_0_23_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2532_ _1013_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__inv_2
X_2463_ _0593_ _0703_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__nand2_1
X_3581_ clknet_4_2_0_clk _0028_ VGND VGND VPWR VPWR clk_div.counter\[7\] sky130_fd_sc_hd__dfxtp_1
X_2601_ _1078_ _1079_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2394_ _0661_ _0805_ _0592_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__a21o_1
X_3015_ _1134_ _1464_ _1465_ _1469_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__a31o_1
XFILLER_0_48_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3779_ clknet_4_10_0_clk _0226_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1894_ _0386_ _0388_ _0392_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__a21o_1
X_3702_ clknet_4_12_0_clk _0149_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_3633_ clknet_4_7_0_clk _0080_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_1963_ _0453_ _0459_ _0461_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__a21oi_2
X_3495_ _1739_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__clkbuf_1
X_2446_ _0862_ _0929_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__nand2_1
X_3564_ clk_div.slow_clk _0006_ VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__dfxtp_1
X_2515_ _0996_ _0997_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2377_ reg_file.memory\[5\]\[3\] _0238_ _0577_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_46_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_4_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2300_ _0672_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__clkbuf_4
X_3280_ reg_file.memory\[0\]\[18\] VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__clkbuf_1
X_2231_ reg_file.memory\[25\]\[9\] _0663_ _0715_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__o21a_1
X_2093_ _0578_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__clkbuf_4
X_2162_ reg_file.memory\[5\]\[6\] reg_file.memory\[15\]\[6\] _0594_ VGND VGND VPWR
+ VPWR _0648_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2995_ _0686_ _0797_ _0886_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3616_ clk_div.slow_clk _0063_ VGND VGND VPWR VPWR seven_seg_conv.temp\[22\] sky130_fd_sc_hd__dfxtp_1
X_1877_ _0362_ _0365_ _0375_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__o21a_1
X_3547_ _0254_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[21\] sky130_fd_sc_hd__dlxtn_1
XFILLER_0_9_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1946_ _0435_ _0444_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__or2b_1
X_3478_ _1730_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__clkbuf_1
X_2429_ _0686_ _0712_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1800_ _0298_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__buf_6
XFILLER_0_57_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2780_ _1241_ _1249_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3401_ reg_file.memory\[15\]\[11\] alu.ALUResult\[11\] _1688_ VGND VGND VPWR VPWR
+ _1690_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2214_ _0698_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3332_ _1653_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__clkbuf_1
X_3263_ _1617_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__clkbuf_1
X_3194_ reg_file.memory\[5\]\[8\] alu.ALUResult\[8\] _1573_ VGND VGND VPWR VPWR _1582_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2145_ _0614_ _0616_ _0621_ _0630_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__and4_1
XFILLER_0_48_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2076_ _0564_ _0566_ _0567_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__mux2_1
X_2978_ _0976_ _0870_ _1319_ _0868_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__a31o_1
X_1929_ _0274_ _0424_ _0426_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2901_ _0893_ _0895_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__and2_1
X_2832_ _1297_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_41_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2763_ _0600_ _0602_ _1182_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_33_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2694_ _1148_ _1167_ _0888_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3315_ _1644_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__clkbuf_1
X_3246_ reg_file.memory\[0\]\[1\] VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__clkbuf_1
X_3177_ _1572_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__buf_4
X_2128_ _0585_ _0613_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__nand2_1
X_2059_ _0554_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__buf_6
XFILLER_0_44_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3100_ clk_div.counter\[15\] clk_div.counter\[16\] _1527_ VGND VGND VPWR VPWR _1529_
+ sky130_fd_sc_hd__and3_1
X_3031_ PC\[0\] PC\[1\] VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_78_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2815_ _1280_ _1281_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__or2b_1
X_2746_ _1216_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__inv_2
XFILLER_0_5_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2677_ _1136_ _1138_ _1147_ _1152_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__a211o_1
X_3229_ _1600_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_52_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3580_ clknet_4_2_0_clk _0027_ VGND VGND VPWR VPWR clk_div.counter\[6\] sky130_fd_sc_hd__dfxtp_1
X_2600_ _1054_ _1057_ _1058_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__o21a_1
XFILLER_0_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2531_ _0897_ _0902_ _0698_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__mux2_1
X_2393_ _0728_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__clkbuf_4
X_2462_ _0945_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__inv_2
XFILLER_0_64_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3014_ _0579_ _1348_ _1468_ _0934_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_73_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3778_ clknet_4_10_0_clk _0225_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_2729_ _0597_ _0621_ _1153_ _1175_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__a31o_1
XFILLER_0_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1962_ _0458_ _0455_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__and2_1
XFILLER_0_70_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1893_ _0382_ _0391_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__and2_1
X_3701_ clknet_4_12_0_clk _0148_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_3563_ clk_div.slow_clk _0005_ VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__dfxtp_1
X_3632_ clknet_4_6_0_clk _0079_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_3494_ reg_file.memory\[25\]\[23\] alu.ALUResult\[23\] _1735_ VGND VGND VPWR VPWR
+ _1739_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2376_ _0841_ _0859_ _0860_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__mux2_1
X_2445_ _0928_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__buf_2
X_2514_ _0751_ _0995_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_19_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2230_ reg_file.memory\[0\]\[9\] _0665_ _0668_ reg_file.memory\[10\]\[9\] _0671_
+ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__a221o_1
XFILLER_0_45_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2092_ reg_file.memory\[5\]\[3\] _0238_ _0577_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__a21o_4
X_2161_ _0583_ _0646_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2994_ _1442_ _1448_ _0873_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__a21o_1
X_1945_ _1760_ _0433_ _0432_ _0436_ _0439_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__a311o_1
X_3615_ clk_div.slow_clk _0062_ VGND VGND VPWR VPWR seven_seg_conv.temp\[21\] sky130_fd_sc_hd__dfxtp_1
X_1876_ _0367_ _0365_ _0368_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__nand3_1
X_3546_ _0253_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[20\] sky130_fd_sc_hd__dlxtn_1
XFILLER_0_43_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2359_ _0661_ _0843_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3477_ reg_file.memory\[25\]\[15\] alu.ALUResult\[15\] _1724_ VGND VGND VPWR VPWR
+ _1730_ sky130_fd_sc_hd__mux2_1
X_2428_ _0781_ _0911_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__nor2_1
XFILLER_0_74_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3400_ _1689_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3331_ alu.ALUResult\[10\] reg_file.memory\[10\]\[10\] _1652_ VGND VGND VPWR VPWR
+ _1653_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2144_ _0623_ _0625_ _0627_ _0629_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__and4_1
X_3193_ _1581_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__clkbuf_1
X_3262_ reg_file.memory\[0\]\[9\] VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__clkbuf_1
X_2213_ _0697_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_72_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2075_ _0009_ _0011_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__xnor2_1
X_1859_ _0348_ _0357_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__and2_1
X_2977_ _1195_ _1375_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__nor2_1
X_1928_ _0274_ _0426_ _0424_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__nand3_1
XFILLER_0_31_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3529_ _0266_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[3\] sky130_fd_sc_hd__dlxtn_1
XPHY_EDGE_ROW_24_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2900_ _1360_ _1361_ _0868_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__o21a_1
XFILLER_0_9_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2831_ _0843_ _1295_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_41_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2762_ _1134_ _1222_ _1223_ _1232_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_33_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_60_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2693_ _0686_ _0950_ _0947_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__o21ai_1
X_3314_ alu.ALUResult\[2\] reg_file.memory\[10\]\[2\] _1641_ VGND VGND VPWR VPWR _1644_
+ sky130_fd_sc_hd__mux2_1
X_2127_ reg_file.memory\[5\]\[25\] reg_file.memory\[15\]\[25\] _0603_ VGND VGND VPWR
+ VPWR _0613_ sky130_fd_sc_hd__mux2_1
X_3245_ _1608_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3176_ PC\[2\] _0013_ ctrl_unit.RegWrite VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__and3_2
XFILLER_0_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2058_ _0552_ _0553_ _0543_ seven_seg_conv.current_digit\[2\] VGND VGND VPWR VPWR
+ _0554_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_50_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3030_ alu.ALUControl\[1\] alu.ALUControl\[2\] VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__nor2_8
XFILLER_0_53_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2814_ _0847_ _1279_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2676_ _1096_ _0938_ _1151_ _0870_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__o211a_1
X_2745_ _0602_ _1215_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3159_ _0348_ _0350_ seven_seg_conv.digit_counter\[3\] VGND VGND VPWR VPWR _1563_
+ sky130_fd_sc_hd__a21o_1
X_3228_ reg_file.memory\[5\]\[24\] alu.ALUResult\[24\] _1595_ VGND VGND VPWR VPWR
+ _1600_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_52_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2530_ _0882_ _0894_ _0888_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2461_ _0941_ _0944_ _0699_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__mux2_1
X_2392_ _0778_ _0874_ _0875_ _0876_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__o2bb2a_1
X_3013_ _0974_ _1408_ _1467_ _0956_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__o211a_1
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3777_ clknet_4_10_0_clk _0224_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_2728_ _1187_ _1188_ _1185_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__o21a_1
X_2659_ _1135_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1892_ _0389_ _0384_ _0390_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_43_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3700_ clknet_4_7_0_clk _0147_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_1961_ _0456_ _0453_ _0459_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__mux2_2
X_3493_ _1738_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__clkbuf_1
X_3562_ clk_div.slow_clk _0004_ VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__dfxtp_1
X_2513_ _0751_ _0995_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__nand2_1
X_3631_ clknet_4_6_0_clk _0078_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_2375_ _0725_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__clkbuf_4
X_2444_ _0771_ _0775_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2160_ reg_file.memory\[5\]\[7\] reg_file.memory\[15\]\[7\] _0594_ VGND VGND VPWR
+ VPWR _0646_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2091_ PC\[0\] reg_file.memory\[15\]\[3\] _0575_ _0576_ _0574_ VGND VGND VPWR VPWR
+ _0577_ sky130_fd_sc_hd__o311a_1
X_2993_ _1442_ _1448_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__nor2_1
X_3614_ clk_div.slow_clk _0061_ VGND VGND VPWR VPWR seven_seg_conv.temp\[20\] sky130_fd_sc_hd__dfxtp_1
X_1875_ _0285_ _0372_ _0373_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__or3_1
XFILLER_0_43_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1944_ _0441_ _0442_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__or2_1
X_3545_ _0251_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[19\] sky130_fd_sc_hd__dlxtn_1
X_2427_ _0891_ _0909_ _0910_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__mux2_1
X_3476_ _1729_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
X_2358_ reg_file.memory\[25\]\[19\] _0664_ _0842_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__o21a_1
XFILLER_0_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2289_ _0582_ _0773_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3330_ _1640_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_13_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2143_ _0585_ _0628_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__nand2_1
X_2212_ _0582_ _0695_ _0696_ _0240_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__a31o_1
X_3261_ _1616_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__clkbuf_1
X_3192_ reg_file.memory\[5\]\[7\] alu.ALUResult\[7\] _1573_ VGND VGND VPWR VPWR _1581_
+ sky130_fd_sc_hd__mux2_1
X_2074_ _0545_ _0565_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2976_ _1430_ _1432_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__xnor2_1
X_1858_ _0356_ _0350_ _0353_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_56_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1927_ _0417_ _0418_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1789_ _0287_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__inv_1
X_3528_ _0263_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[2\] sky130_fd_sc_hd__dlxtn_1
X_3459_ _1720_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_27_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2830_ _0843_ _1295_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_41_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2761_ _1083_ _1228_ _1229_ _1231_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__a2bb2o_1
X_2692_ _1157_ _1158_ _1163_ _0870_ _1166_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__a221o_1
XFILLER_0_5_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_1 alu.ALUResult\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3244_ reg_file.memory\[0\]\[0\] VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__clkbuf_1
X_3313_ _1643_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__clkbuf_1
X_3175_ alu.ALUResult\[31\] _0279_ _1571_ seven_seg_conv.temp\[28\] _1545_ VGND VGND
+ VPWR VPWR _0069_ sky130_fd_sc_hd__a32o_1
X_2126_ _0605_ _0607_ _0609_ _0611_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__and4_1
X_2057_ _1755_ _0551_ _0540_ seven_seg_conv.digit_counter\[3\] VGND VGND VPWR VPWR
+ _0553_ sky130_fd_sc_hd__a31oi_1
X_2959_ _0805_ _1416_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput3 net3 VGND VGND VPWR VPWR an[0] sky130_fd_sc_hd__buf_1
XFILLER_0_50_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2813_ _0847_ _1279_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2675_ _0956_ _1150_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__nand2_1
X_2744_ _0600_ _1214_ _1183_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3793_ clknet_4_1_0_clk _0240_ VGND VGND VPWR VPWR alu.ALUControl\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_69_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3227_ _1599_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3158_ _1543_ _0359_ _1562_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_49_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2109_ _0594_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__clkbuf_4
X_3089_ _1521_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_52_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2460_ _0942_ _0943_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2391_ _0679_ _0761_ _0873_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__a21o_1
X_3012_ _0748_ _1436_ _1466_ _0974_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__o211ai_1
X_3776_ clknet_4_11_0_clk _0223_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2589_ _0877_ _0919_ _0931_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__o21a_1
X_2727_ _1134_ _1189_ _1190_ _1199_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__a31o_1
X_2658_ _1125_ _1133_ _1134_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1891_ _0380_ _0381_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__and2_1
XFILLER_0_43_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3630_ clknet_4_6_0_clk _0077_ VGND VGND VPWR VPWR reg_file.memory\[5\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_1960_ _0457_ _0450_ _0458_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__o21ai_1
X_3492_ reg_file.memory\[25\]\[22\] alu.ALUResult\[22\] _1735_ VGND VGND VPWR VPWR
+ _1738_ sky130_fd_sc_hd__mux2_1
X_2443_ _0921_ _0922_ _0923_ _0926_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__a31o_1
X_3561_ clk_div.slow_clk _0003_ VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2512_ _0728_ _0994_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__xnor2_1
X_2374_ _0850_ _0858_ _0719_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3759_ clknet_4_6_0_clk _0206_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2090_ PC\[0\] PC\[1\] VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__nand2_1
X_2992_ _1445_ _1447_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1874_ _0364_ _0361_ _0369_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__and3_1
X_3613_ clk_div.slow_clk _0060_ VGND VGND VPWR VPWR seven_seg_conv.temp\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1943_ _0440_ _0435_ _0438_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__a21oi_1
X_2426_ _0863_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_51_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3544_ _0250_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[18\] sky130_fd_sc_hd__dlxtn_1
X_3475_ reg_file.memory\[25\]\[14\] alu.ALUResult\[14\] _1724_ VGND VGND VPWR VPWR
+ _1729_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2357_ reg_file.memory\[0\]\[19\] _0666_ _0669_ reg_file.memory\[10\]\[19\] _0672_
+ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__a221o_1
XFILLER_0_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2288_ reg_file.memory\[5\]\[5\] reg_file.memory\[15\]\[5\] _0594_ VGND VGND VPWR
+ VPWR _0773_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3260_ reg_file.memory\[0\]\[8\] VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2142_ reg_file.memory\[5\]\[23\] reg_file.memory\[15\]\[23\] _0603_ VGND VGND VPWR
+ VPWR _0628_ sky130_fd_sc_hd__mux2_1
X_2073_ _0547_ _0012_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__or2_1
X_2211_ PC\[2\] _0576_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__nor2_1
X_3191_ _1580_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2975_ _1414_ _1431_ _1417_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__a21o_1
X_1788_ alu.ALUResult\[23\] seven_seg_conv.temp\[23\] _1751_ VGND VGND VPWR VPWR _0287_
+ sky130_fd_sc_hd__mux2_1
X_1857_ _0343_ _0344_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__nor2_1
X_1926_ _0274_ _0424_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__xnor2_2
X_3527_ _0252_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[1\] sky130_fd_sc_hd__dlxtn_1
XFILLER_0_24_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2409_ _0789_ _0825_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__nand2_1
X_3389_ _1683_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__clkbuf_1
X_3458_ reg_file.memory\[25\]\[6\] alu.ALUResult\[6\] _1713_ VGND VGND VPWR VPWR _1720_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_27_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_41_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2760_ _0976_ _1090_ _1230_ _0780_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__a211o_1
X_2691_ _0771_ _1164_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__a21oi_1
XANTENNA_2 _0006_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3243_ _1607_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_67_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3312_ alu.ALUResult\[1\] reg_file.memory\[10\]\[1\] _1641_ VGND VGND VPWR VPWR _1643_
+ sky130_fd_sc_hd__mux2_1
X_3174_ alu.ALUResult\[29\] alu.ALUResult\[30\] VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__or2_1
X_2125_ _0585_ _0610_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__nand2_1
X_2056_ _1755_ _0541_ _0551_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__a21o_1
XFILLER_0_16_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2958_ _0634_ _1415_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1909_ _0406_ _0407_ _0398_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2889_ _0929_ _1091_ _1344_ _1134_ _1351_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__a221o_1
XFILLER_0_67_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput4 net4 VGND VGND VPWR VPWR an[1] sky130_fd_sc_hd__buf_1
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2812_ _0638_ _1278_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__xnor2_1
X_3792_ clknet_4_3_0_clk _0239_ VGND VGND VPWR VPWR alu.ALUControl\[1\] sky130_fd_sc_hd__dfxtp_2
X_2743_ alu.ALUControl\[1\] alu.ALUControl\[0\] VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2674_ _1066_ _1149_ _0726_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_69_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3226_ reg_file.memory\[5\]\[23\] alu.ALUResult\[23\] _1595_ VGND VGND VPWR VPWR
+ _1599_ sky130_fd_sc_hd__mux2_1
X_3157_ _1545_ seven_seg_conv.temp\[20\] VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_77_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2039_ _0537_ _0532_ _0533_ _0524_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__o22ai_2
X_2108_ _0587_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__clkbuf_4
X_3088_ clk_div.counter\[12\] _1518_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_43_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3011_ _0793_ _0801_ _0921_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__a21o_1
X_2390_ _0677_ _0761_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3775_ clknet_4_10_0_clk _0222_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2726_ _1083_ _1195_ _1198_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_66_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2657_ _0868_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__clkbuf_4
X_2588_ _0907_ _0945_ _0974_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__mux2_1
X_3209_ reg_file.memory\[5\]\[15\] alu.ALUResult\[15\] _1584_ VGND VGND VPWR VPWR
+ _1590_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1890_ _0378_ _0379_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3560_ clk_div.slow_clk _0002_ VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3491_ _1737_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__clkbuf_1
X_2373_ _0853_ _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__nand2_1
X_2442_ _0748_ _0924_ _0925_ _0877_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__a31o_1
X_2511_ _0697_ _0677_ _0993_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_75_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2709_ _0621_ _1153_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__and2_1
X_3689_ clknet_4_3_0_clk _0136_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3758_ clknet_4_4_0_clk _0205_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[7\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2991_ _1446_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__inv_2
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1942_ _0435_ _0437_ _0438_ _0440_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__o211a_1
X_1873_ _0361_ _0369_ _0364_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__a21oi_1
X_3612_ clk_div.slow_clk _0059_ VGND VGND VPWR VPWR seven_seg_conv.temp\[18\] sky130_fd_sc_hd__dfxtp_1
X_3543_ _0249_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[17\] sky130_fd_sc_hd__dlxtn_1
XFILLER_0_3_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2356_ _0831_ _0840_ _0698_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__mux2_1
X_2425_ _0729_ _0899_ _0908_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__a21oi_1
X_3474_ _1728_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__clkbuf_1
XMain_18 VGND VGND VPWR VPWR cx[0] Main_18/LO sky130_fd_sc_hd__conb_1
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2287_ alu.ALUControl\[1\] alu.ALUControl\[2\] VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__nor2b_2
XFILLER_0_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2210_ reg_file.memory\[15\]\[1\] _0587_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__nand2_1
X_3190_ reg_file.memory\[5\]\[6\] alu.ALUResult\[6\] _1573_ VGND VGND VPWR VPWR _1580_
+ sky130_fd_sc_hd__mux2_1
X_2141_ _0584_ _0626_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__nand2_1
X_2072_ _0545_ _0012_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__nor2_1
XFILLER_0_71_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2974_ _1418_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__inv_2
XFILLER_0_56_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1925_ _0419_ _0420_ _0421_ _0423_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__a211o_2
X_1856_ _0344_ _0353_ _0350_ _0351_ _0354_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__a311o_1
X_1787_ _0285_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__inv_2
X_3526_ _0241_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[0\] sky130_fd_sc_hd__dlxtn_1
X_2408_ _0685_ _0818_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__nand2_1
X_2339_ reg_file.memory\[25\]\[23\] _0782_ _0823_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__o21a_1
X_3388_ reg_file.memory\[15\]\[5\] alu.ALUResult\[5\] _1677_ VGND VGND VPWR VPWR _1683_
+ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3457_ _1719_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_35_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2690_ _1116_ _0983_ _0777_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__o21a_1
X_3311_ _1642_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_20_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3242_ reg_file.memory\[5\]\[31\] alu.ALUResult\[31\] _1572_ VGND VGND VPWR VPWR
+ _1607_ sky130_fd_sc_hd__mux2_1
X_3173_ _1543_ seven_seg_conv.temp\[27\] _1570_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__a21o_1
X_2124_ reg_file.memory\[5\]\[28\] reg_file.memory\[15\]\[28\] _0603_ VGND VGND VPWR
+ VPWR _0610_ sky130_fd_sc_hd__mux2_1
X_2055_ _0533_ _0534_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__nor2_1
XFILLER_0_16_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1839_ _0289_ _0329_ _0336_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__or3_1
X_2957_ _0607_ _1400_ _1325_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__a21o_1
X_2888_ _0771_ _1349_ _1350_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__a21oi_1
X_1908_ _0406_ _0401_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_32_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3509_ _1746_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput5 net5 VGND VGND VPWR VPWR an[2] sky130_fd_sc_hd__buf_1
XFILLER_0_37_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2811_ _0623_ _0657_ _1233_ _1175_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__a31o_1
X_2742_ _0968_ _1207_ _1213_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_26_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3791_ clknet_4_3_0_clk _0238_ VGND VGND VPWR VPWR alu.ALUControl\[2\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_78_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2673_ _1104_ _1148_ _0699_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_77_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2107_ _0592_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_69_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3156_ _1543_ seven_seg_conv.temp\[19\] _1561_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__a21o_1
X_3225_ _1598_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3087_ clk_div.counter\[12\] _1518_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__or2_1
XFILLER_0_49_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2038_ _0536_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__inv_2
XFILLER_0_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_43_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3010_ _1462_ _1463_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__or2_1
XFILLER_0_64_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3774_ clknet_4_10_0_clk _0221_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_2725_ _0777_ _1196_ _1197_ _0771_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__a22o_1
X_2656_ _1126_ _1132_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2587_ _0937_ _1066_ _0765_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__mux2_1
X_3208_ _1589_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__clkbuf_1
X_3139_ _0429_ _0432_ _1545_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__a21o_1
XFILLER_0_64_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3490_ reg_file.memory\[25\]\[21\] alu.ALUResult\[21\] _1735_ VGND VGND VPWR VPWR
+ _1737_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2510_ _0959_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__buf_2
XFILLER_0_59_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2372_ _0789_ _0856_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__nand2_1
X_2441_ _0749_ _0758_ _0593_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_19_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_49_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2708_ _1171_ _1172_ _1173_ _1181_ _0968_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__o32a_1
X_2639_ _0775_ _0863_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__nand2_1
X_3688_ clknet_4_3_0_clk _0135_ VGND VGND VPWR VPWR reg_file.memory\[10\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3757_ clknet_4_5_0_clk _0204_ VGND VGND VPWR VPWR reg_file.memory\[25\]\[6\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_58_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_67_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2990_ _0799_ _1444_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1872_ _0362_ _0365_ _0370_ _0363_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__a22o_1
XFILLER_0_28_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1941_ _0439_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__inv_2
X_3611_ clk_div.slow_clk _0058_ VGND VGND VPWR VPWR seven_seg_conv.temp\[17\] sky130_fd_sc_hd__dfxtp_1
X_3542_ _0248_ _0007_ VGND VGND VPWR VPWR alu.ALUResult\[16\] sky130_fd_sc_hd__dlxtn_1
X_3473_ reg_file.memory\[25\]\[13\] alu.ALUResult\[13\] _1724_ VGND VGND VPWR VPWR
+ _1728_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2355_ _0835_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__nand2_1
X_2424_ _0877_ _0907_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__nor2_1
X_2286_ _0770_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__buf_2
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2140_ reg_file.memory\[5\]\[21\] reg_file.memory\[15\]\[21\] _0595_ VGND VGND VPWR
+ VPWR _0626_ sky130_fd_sc_hd__mux2_1
X_2071_ _0009_ _0560_ _0563_ _0555_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__o22a_1
XFILLER_0_71_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2973_ _1428_ _1429_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__or2b_1
X_1855_ alu.ALUResult\[21\] seven_seg_conv.temp\[21\] _1751_ VGND VGND VPWR VPWR _0354_
+ sky130_fd_sc_hd__mux2_1
X_1924_ _0413_ _0412_ _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__a21oi_1
X_1786_ alu.ALUResult\[19\] seven_seg_conv.temp\[19\] _1751_ VGND VGND VPWR VPWR _0285_
+ sky130_fd_sc_hd__mux2_1
X_3456_ reg_file.memory\[25\]\[5\] alu.ALUResult\[5\] _1713_ VGND VGND VPWR VPWR _1719_
+ sky130_fd_sc_hd__mux2_1
X_3525_ clknet_4_4_0_clk _0008_ VGND VGND VPWR VPWR ctrl_unit.RegWrite sky130_fd_sc_hd__dfxtp_1
X_2338_ reg_file.memory\[0\]\[23\] _0783_ _0784_ reg_file.memory\[10\]\[23\] _0785_
+ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__a221o_1
X_2407_ _0877_ _0883_ _0890_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3387_ _1682_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__clkbuf_1
X_2269_ _0660_ _0753_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3310_ alu.ALUResult\[0\] reg_file.memory\[10\]\[0\] _1641_ VGND VGND VPWR VPWR _1642_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3172_ _0297_ _0299_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__nand2_1
X_3241_ _1606_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__clkbuf_1
X_2123_ _0585_ _0608_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2054_ _0550_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_16_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1838_ _0334_ _0336_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__nand2_1
X_2956_ _0808_ _1402_ _1405_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__a21o_1
X_2887_ _1257_ _1087_ _1083_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__o21a_1
X_1907_ _0282_ _0394_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_32_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3508_ reg_file.memory\[25\]\[30\] alu.ALUResult\[30\] _1712_ VGND VGND VPWR VPWR
+ _1746_ sky130_fd_sc_hd__mux2_1
X_3439_ _1709_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__clkbuf_1
X_1769_ alu.ALUResult\[2\] seven_seg_conv.temp\[2\] _1753_ VGND VGND VPWR VPWR _1756_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput6 net6 VGND VGND VPWR VPWR an[3] sky130_fd_sc_hd__buf_1
XFILLER_0_37_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3790_ clk_div.slow_clk _0237_ VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__dfxtp_1
X_2741_ _1061_ _1117_ _1211_ _1083_ _1212_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__o221a_1
X_2810_ _1134_ _1270_ _1271_ _1277_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__a31o_1
X_2672_ _0913_ _0948_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3224_ reg_file.memory\[5\]\[22\] alu.ALUResult\[22\] _1595_ VGND VGND VPWR VPWR
+ _1598_ sky130_fd_sc_hd__mux2_1
.ends
